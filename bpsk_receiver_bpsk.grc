options:
  parameters:
    author: Pixel_Pulse
    generate_options: qt_gui
    id: Version_1
    output_language: python
    title: CDP
  states: {}

blocks:
- name: bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1,1] '
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1,]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0,0.7,0.4,0.15]'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1.002'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_3
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '15'
    sps: '1'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1]'
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """Prints PDU payloads as readable ASCII text"""

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Plain Text Printer',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  data_pmt = pmt.cdr(msg)
                  try:
                      raw_bytes = bytes(pmt.u8vector_elements(data_pmt))
                      text = raw_bytes.decode('utf-8', errors='ignore')
                      print(f"\nSUCCESS! RECEIVED MESSAGE: {text}\n")
                  except Exception as e:
                      print("Could not decode text:", e)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Packet Parser
      Strips the SRC/DST/TYPE/SEQ/TOTAL/LEN header, filters on DST address,
      and reassembles multi-segment messages before publishing the full payload.
      """
      import struct
      from gnuradio import gr
      import pmt

      HEADER_LEN = 7  # B B B B B H
      TYPE_NAMES = {0x01: 'TEXT', 0x02: 'IMAGE', 0x03: 'AUDIO'}

      class blk(gr.basic_block):
          def __init__(self, my_addr=0x02):
              gr.basic_block.__init__(self, name='Packet Parser', in_sig=None, out_sig=None)
              self.my_addr = my_addr & 0xFF
              self._reassembly = {}
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              try:
                  raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              if len(raw) < HEADER_LEN:
                  print("Packet Parser: runt packet, dropping")
                  return

              src, dst, mtype, seq, total, plen = struct.unpack('>BBBBBH', raw[:HEADER_LEN])
              payload = raw[HEADER_LEN:HEADER_LEN + plen]

              if dst != self.my_addr and dst != 0xFF:  # 0xFF = broadcast
                  print(f"Packet Parser: dropping pkt for {dst:#x} (I'm {self.my_addr:#x})")
                  return

              print(f"RX pkt  src={src:#x} dst={dst:#x} type={TYPE_NAMES.get(mtype, mtype)} "
                    f"seg={seq+1}/{total} len={plen}")

              key = (src, mtype)
              self._reassembly.setdefault(key, {})[seq] = payload

              if len(self._reassembly[key]) == total:
                  full = b''.join(self._reassembly[key][i] for i in range(total))
                  del self._reassembly[key]
                  out_vec = pmt.init_u8vector(len(full), list(full))
                  meta = pmt.cons(pmt.intern("type"), pmt.from_long(mtype))
                  self.message_port_pub(pmt.intern('pdu_out'), pmt.cons(meta, out_vec))
    my_addr: '3'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    manual_gain1: '80'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: '''ip:192.168.1.10'''
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_check_0_0, ok, epy_block_1, pdu_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_1, pdu_out, blocks_message_debug_3, print_pdu]
- [epy_block_1, pdu_out, epy_block_0, pdu_in]
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
