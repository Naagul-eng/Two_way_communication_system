options:
  parameters:
    author: naagul
    description: Radio chess + encrypted text chat over QPSK/FEC/CRC/ACK link.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: radio_chess_Loopback_Test
    output_language: python
    title: Single-laptop loopback test (both colours playable)
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.001'
    type: cma
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fec_enabled
  id: variable
  parameters:
    comment: Enable/bypass on BOTH peers together; restart after changing.
    value: 'True'
  states: {}
- name: fec_log_every
  id: variable
  parameters:
    comment: Use 1 for every packet; 50 for file transfers.
    value: '50'
  states: {}
- name: fec_nsym
  id: variable
  parameters:
    comment: Parity bytes per codeword. Must match peer; restart after changing.
    value: '16'
  states: {}
- name: fec_verbose
  id: variable
  parameters:
    comment: Print corrections, failures and periodic packet counts.
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''A1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: peer_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: shared_key
  id: variable
  parameters:
    value: b'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P='
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '5'
    sps: '2'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    constellation: digital.constellation_qpsk().base()
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import threading
      import time


      class blk(gr.basic_block):
          """Observe RS/CRC outcomes; counters include controls and retransmissions."""
          def __init__(self, report_interval=1.0):
              gr.basic_block.__init__(self, name="Link Reliability Monitor",
                                      in_sig=None, out_sig=None)
              self.interval = max(0.2, float(report_interval))
              self._lock = threading.Lock()
              self._print_lock = threading.Lock()
              self._halt = threading.Event()
              self._worker = None
              self.counts = dict.fromkeys((
                  "tx", "rs_ok", "rs_fail", "corrected_packets", "corrected_bytes",
                  "corrected_bits", "crc_ok", "crc_fail", "crc_ok_bytes",
                  "missing_metadata"), 0)
              self._last_time = time.monotonic()
              self._last_bytes = 0
              for port in ("tx", "rs_ok", "rs_fail", "crc_ok", "crc_fail"):
                  self.message_port_register_in(pmt.intern(port))
              self.set_msg_handler(pmt.intern("tx"), self.handle_tx)
              self.set_msg_handler(pmt.intern("rs_ok"), self.handle_rs_ok)
              self.set_msg_handler(pmt.intern("rs_fail"), self.handle_rs_fail)
              self.set_msg_handler(pmt.intern("crc_ok"), self.handle_crc_ok)
              self.set_msg_handler(pmt.intern("crc_fail"), self.handle_crc_fail)

          def handle_tx(self, msg):
              with self._lock:
                  self.counts["tx"] += 1

          def handle_rs_ok(self, msg):
              changed_bytes = changed_bits = 0
              available = False
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  bk, ik = pmt.intern("rs_corrected_bytes"), pmt.intern("rs_corrected_bits")
                  if pmt.is_dict(meta) and pmt.dict_has_key(meta, bk) and pmt.dict_has_key(meta, ik):
                      changed_bytes = pmt.to_long(pmt.dict_ref(meta, bk, pmt.from_long(0)))
                      changed_bits = pmt.to_long(pmt.dict_ref(meta, ik, pmt.from_long(0)))
                      available = True
              with self._lock:
                  self.counts["rs_ok"] += 1
                  self.counts["corrected_packets"] += int(changed_bytes > 0)
                  self.counts["corrected_bytes"] += changed_bytes
                  self.counts["corrected_bits"] += changed_bits
                  self.counts["missing_metadata"] += int(not available)

          def handle_rs_fail(self, msg):
              with self._lock:
                  self.counts["rs_fail"] += 1

          def handle_crc_ok(self, msg):
              size = 0
              if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):
                  size = len(pmt.u8vector_elements(pmt.cdr(msg)))
              with self._lock:
                  self.counts["crc_ok"] += 1
                  self.counts["crc_ok_bytes"] += size

          def handle_crc_fail(self, msg):
              with self._lock:
                  self.counts["crc_fail"] += 1

          @staticmethod
          def percent(value, total):
              return f"{100.0 * value / total:.2f}%" if total else "n/a"

          def report(self):
              with self._print_lock:
                  with self._lock:
                      c = self.counts.copy()
                  now = time.monotonic()
                  elapsed = max(now - self._last_time, 1e-9)
                  rate = 8.0 * (c["crc_ok_bytes"] - self._last_bytes) / elapsed / 1000.0
                  self._last_time, self._last_bytes = now, c["crc_ok_bytes"]
                  rs_total = c["rs_ok"] + c["rs_fail"]
                  crc_total = c["crc_ok"] + c["crc_fail"]
                  completed = c["rs_fail"] + crc_total
                  rejected = c["rs_fail"] + c["crc_fail"]
                  print(
                      f"[LINK] TX_PDUs={c['tx']} | "
                      f"RS decoded={c['rs_ok']} fail={c['rs_fail']} "
                      f"({self.percent(c['rs_fail'], rs_total)}) | "
                      f"RS changed packets={c['corrected_packets']} "
                      f"bytes={c['corrected_bytes']} bits={c['corrected_bits']} | "
                      f"CRC pass={c['crc_ok']} fail={c['crc_fail']} "
                      f"({self.percent(c['crc_fail'], crc_total)}) | "
                      f"RS/CRC rejected={self.percent(rejected, completed)} | "
                      f"CRC-pass rate={rate:.2f} kbit/s | "
                      f"missing_RS_metadata={c['missing_metadata']}", flush=True)

          def _report_loop(self):
              while not self._halt.wait(self.interval):
                  self.report()

          def start(self):
              self._halt.clear()
              with self._lock:
                  self._last_bytes = self.counts["crc_ok_bytes"]
              self._last_time = time.monotonic()
              self._worker = threading.Thread(target=self._report_loop,
                                              name="link-reliability-monitor", daemon=True)
              self._worker.start()
              return True

          def stop(self):
              self._halt.set()
              if self._worker is not None:
                  self._worker.join()
              self.report()
              return True
    comment: One report per second. RS changes include parity; rates include ACKs and retransmissions. Not end-to-end loss or BER.
    report_interval: '1.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: Chess Protocol — encrypted forwarding of chess packets to/from the radio chain.

      command_in  <- Chess GUI command_out   (JSON dict, chess==1) -> Fernet encrypt -> tx_out    -> CRC append -> RS encoder -> TX
      rx_in       <- CRC check ok output     (b'CH'+token)         -> Fernet decrypt -> event_out -> Chess GUI event_in
      Anything that is not an authentic chess frame (wrong key, other protocol traffic) is silently ignored.
      """
      import json
      from cryptography.fernet import Fernet, InvalidToken
      from gnuradio import gr
      import pmt

      _TAG = b'CH'


      class blk(gr.basic_block):
          def __init__(self, my_addr='A1', peer_addr='B1', time_control='3+0', player_color='random',
                       shared_key=b'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P='):
              gr.basic_block.__init__(self, name='Chess Protocol', in_sig=None, out_sig=None)
              self.my_addr = my_addr
              self.peer_addr = peer_addr
              self.time_control = time_control
              self.player_color = player_color
              if isinstance(shared_key, str):
                  shared_key = shared_key.encode('ascii')
              self.cipher = Fernet(shared_key)
              for name in ('rx_in', 'command_in'):
                  self.message_port_register_in(pmt.intern(name))
                  self.set_msg_handler(pmt.intern(name), getattr(self, '_' + name))
              for name in ('tx_out', 'event_out'):
                  self.message_port_register_out(pmt.intern(name))

          @staticmethod
          def _bytes(msg):
              if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):
                  return bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              return None

          def decode(self, raw):
              """b'CH'+token -> dict, or None if not an authentic chess frame."""
              if raw is None or not raw.startswith(_TAG):
                  return None
              try:
                  d = json.loads(self.cipher.decrypt(raw[len(_TAG):]).decode('utf-8'))
              except (InvalidToken, ValueError, UnicodeError):
                  return None
              return d if isinstance(d, dict) and d.get('chess') == 1 else None

          def encode(self, d):
              return _TAG + self.cipher.encrypt(json.dumps(d, separators=(',', ':')).encode('utf-8'))

          @staticmethod
          def _wrap(raw):
              return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))

          def _command_in(self, msg):
              raw = self._bytes(msg)
              if raw is None:
                  return
              try:
                  d = json.loads(raw.decode('utf-8'))
              except ValueError:
                  return
              if isinstance(d, dict) and d.get('chess') == 1:
                  self.message_port_pub(pmt.intern('tx_out'), self._wrap(self.encode(d)))

          def _rx_in(self, msg):
              d = self.decode(self._bytes(msg))
              if d is not None:
                  ev = json.dumps({'direction': 'peer_move', 'data': d}, separators=(',', ':')).encode('utf-8')
                  self.message_port_pub(pmt.intern('event_out'), self._wrap(ev))
    my_addr: my_addr
    peer_addr: peer_addr
    player_color: '''white'''
    time_control: '''5+0'''
    shared_key: shared_key
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: Chess.com-style GUI, full chess rules, clocks, radio sync.

      Ports:  event_in  <- 'Chess Protocol' event_out
              command_out -> 'Chess Protocol' command_in
      Chat:   chat_out -> Transfer Protocol command_in ; Transfer Protocol event_out -> chat_in
              (text chat uses the encrypted, ACK-based transfer protocol, like the original chat GUI)
      echo_test=True  : ONE window controls BOTH colours (use for single-laptop channel-model testing)
      echo_test=False : you only move your own colour; moves go over the radio to the other node
                        (the two nodes MUST have different my_addr values, e.g. 'A' and 'B')
      """
      import html as _html
      import json
      import random
      import time
      import numpy as np
      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore, QtGui

      FILES = 'abcdefgh'
      KN = [(-2, -1), (-2, 1), (-1, -2), (-1, 2), (1, -2), (1, 2), (2, -1), (2, 1)]
      KG = [(-1, -1), (-1, 0), (-1, 1), (0, -1), (0, 1), (1, -1), (1, 0), (1, 1)]
      DIAG = [(-1, -1), (-1, 1), (1, -1), (1, 1)]
      ORTH = [(-1, 0), (1, 0), (0, -1), (0, 1)]

      # (label, base seconds, increment seconds)
      TCS = [("Bullet 1+0", 60, 0), ("Bullet 2+1", 120, 1), ("Blitz 3+0", 180, 0),
             ("Blitz 3+1", 180, 1), ("Blitz 5+0", 300, 0), ("Rapid 10+0", 600, 0),
             ("Rapid 15+10", 900, 10), ("Classical 30+0", 1800, 0)]


      def inb(r, c):
          return 0 <= r < 8 and 0 <= c < 8


      def sq_name(r, c):
          return FILES[c] + str(8 - r)


      def uci(m):
          return sq_name(m[0], m[1]) + sq_name(m[2], m[3]) + (m[4] or '')


      class Position:
          """Row 0 = rank 8 (black side), row 7 = rank 1. Uppercase = white."""

          def __init__(self):
              self.board = [list('rnbqkbnr'), list('pppppppp')] + [['.'] * 8 for _ in range(4)] + \
                           [list('PPPPPPPP'), list('RNBQKBNR')]
              self.turn = 'w'
              self.castle = set('KQkq')
              self.ep = None
              self.half = 0
              self.full = 1

          def copy(self):
              n = Position.__new__(Position)
              n.board = [row[:] for row in self.board]
              n.turn = self.turn
              n.castle = set(self.castle)
              n.ep = self.ep
              n.half = self.half
              n.full = self.full
              return n

          def key(self):
              return (''.join(''.join(r) for r in self.board), self.turn,
                      ''.join(sorted(self.castle)), self.ep)

          def find_king(self, color):
              k = 'K' if color == 'w' else 'k'
              for r in range(8):
                  for c in range(8):
                      if self.board[r][c] == k:
                          return r, c
              return None

          def attacked(self, r, c, by):
              b = self.board
              white = (by == 'w')
              pr = r + 1 if white else r - 1
              pawn = 'P' if white else 'p'
              for dc in (-1, 1):
                  if inb(pr, c + dc) and b[pr][c + dc] == pawn:
                      return True
              kn = 'N' if white else 'n'
              for dr, dc in KN:
                  rr, cc = r + dr, c + dc
                  if inb(rr, cc) and b[rr][cc] == kn:
                      return True
              kg = 'K' if white else 'k'
              for dr, dc in KG:
                  rr, cc = r + dr, c + dc
                  if inb(rr, cc) and b[rr][cc] == kg:
                      return True
              for dirs, pieces in ((DIAG, 'BQ'), (ORTH, 'RQ')):
                  for dr, dc in dirs:
                      rr, cc = r + dr, c + dc
                      while inb(rr, cc):
                          p = b[rr][cc]
                          if p != '.':
                              if p.isupper() == white and p.upper() in pieces:
                                  return True
                              break
                          rr += dr
                          cc += dc
              return False

          def in_check(self):
              kr, kc = self.find_king(self.turn)
              return self.attacked(kr, kc, 'b' if self.turn == 'w' else 'w')

          @staticmethod
          def _promo(out, r, c, rr, cc, last):
              if rr == last:
                  for pr in 'qrbn':
                      out.append((r, c, rr, cc, pr))
              else:
                  out.append((r, c, rr, cc, ''))

          def pseudo(self):
              out = []
              b = self.board
              white = self.turn == 'w'
              for r in range(8):
                  for c in range(8):
                      p = b[r][c]
                      if p == '.' or p.isupper() != white:
                          continue
                      t = p.upper()
                      if t == 'P':
                          d = -1 if white else 1
                          start = 6 if white else 1
                          last = 0 if white else 7
                          rr = r + d
                          if inb(rr, c) and b[rr][c] == '.':
                              self._promo(out, r, c, rr, c, last)
                              if r == start and b[r + 2 * d][c] == '.':
                                  out.append((r, c, r + 2 * d, c, ''))
                          for dc in (-1, 1):
                              cc = c + dc
                              if not inb(rr, cc):
                                  continue
                              tg = b[rr][cc]
                              if tg != '.' and tg.isupper() != white:
                                  self._promo(out, r, c, rr, cc, last)
                              elif tg == '.' and self.ep == (rr, cc):
                                  out.append((r, c, rr, cc, ''))
                      elif t == 'N' or t == 'K':
                          for dr, dc in (KN if t == 'N' else KG):
                              rr, cc = r + dr, c + dc
                              if inb(rr, cc) and (b[rr][cc] == '.' or b[rr][cc].isupper() != white):
                                  out.append((r, c, rr, cc, ''))
                          if t == 'K':
                              row = 7 if white else 0
                              opp = 'b' if white else 'w'
                              if r == row and c == 4 and not self.attacked(row, 4, opp):
                                  rook = 'R' if white else 'r'
                                  ks, qs = ('K', 'Q') if white else ('k', 'q')
                                  if (ks in self.castle and b[row][5] == '.' and b[row][6] == '.'
                                          and b[row][7] == rook
                                          and not self.attacked(row, 5, opp)
                                          and not self.attacked(row, 6, opp)):
                                      out.append((row, 4, row, 6, ''))
                                  if (qs in self.castle and b[row][3] == '.' and b[row][2] == '.'
                                          and b[row][1] == '.' and b[row][0] == rook
                                          and not self.attacked(row, 3, opp)
                                          and not self.attacked(row, 2, opp)):
                                      out.append((row, 4, row, 2, ''))
                      else:
                          dirs = DIAG if t == 'B' else ORTH if t == 'R' else DIAG + ORTH
                          for dr, dc in dirs:
                              rr, cc = r + dr, c + dc
                              while inb(rr, cc):
                                  tg = b[rr][cc]
                                  if tg == '.':
                                      out.append((r, c, rr, cc, ''))
                                  else:
                                      if tg.isupper() != white:
                                          out.append((r, c, rr, cc, ''))
                                      break
                                  rr += dr
                                  cc += dc
              return out

          def make(self, m):
              fr, fc, tr, tc, pr = m
              n = self.copy()
              b = n.board
              p = b[fr][fc]
              cap = b[tr][tc]
              white = p.isupper()
              t = p.upper()
              b[fr][fc] = '.'
              if t == 'P' and cap == '.' and fc != tc:      # en passant capture
                  b[fr][tc] = '.'
                  cap = 'x'
              if pr:
                  p = pr.upper() if white else pr.lower()
              b[tr][tc] = p
              if t == 'K' and abs(tc - fc) == 2:            # castling: move the rook
                  if tc == 6:
                      b[tr][5], b[tr][7] = b[tr][7], '.'
                  else:
                      b[tr][3], b[tr][0] = b[tr][0], '.'
              if t == 'K':
                  n.castle -= set('KQ') if white else set('kq')
              corners = {(7, 0): 'Q', (7, 7): 'K', (0, 0): 'q', (0, 7): 'k'}
              for sq in ((fr, fc), (tr, tc)):
                  if sq in corners:
                      n.castle.discard(corners[sq])
              n.ep = ((fr + tr) // 2, fc) if (t == 'P' and abs(tr - fr) == 2) else None
              n.half = 0 if (t == 'P' or cap != '.') else self.half + 1
              if not white:
                  n.full += 1
              n.turn = 'b' if white else 'w'
              return n

          def legal(self):
              res = []
              me = self.turn
              opp = 'b' if me == 'w' else 'w'
              for m in self.pseudo():
                  n = self.make(m)
                  kr, kc = n.find_king(me)
                  if not n.attacked(kr, kc, opp):
                      res.append(m)
              return res

          def insufficient(self):
              pcs = [(p, r, c) for r in range(8) for c in range(8)
                     for p in [self.board[r][c]] if p not in '.kK']
              if not pcs:
                  return True
              if any(p.upper() in 'PRQ' for p, _, _ in pcs):
                  return False
              if len(pcs) == 1:
                  return True
              return all(p.upper() == 'B' for p, _, _ in pcs) and len({(r + c) % 2 for _, r, c in pcs}) == 1

          def san(self, m, legal):
              fr, fc, tr, tc, pr = m
              p = self.board[fr][fc]
              t = p.upper()
              if t == 'K' and abs(tc - fc) == 2:
                  s = 'O-O' if tc == 6 else 'O-O-O'
              else:
                  cap = self.board[tr][tc] != '.' or (t == 'P' and fc != tc)
                  if t == 'P':
                      s = (FILES[fc] + 'x' if cap else '') + sq_name(tr, tc)
                      if pr:
                          s += '=' + pr.upper()
                  else:
                      s = t
                      others = [o for o in legal if o != m and self.board[o[0]][o[1]] == p
                                and o[2] == tr and o[3] == tc]
                      if others:
                          if all(o[1] != fc for o in others):
                              s += FILES[fc]
                          elif all(o[0] != fr for o in others):
                              s += str(8 - fr)
                          else:
                              s += sq_name(fr, fc)
                      s += ('x' if cap else '') + sq_name(tr, tc)
              n = self.make(m)
              if n.in_check():
                  s += '#' if not n.legal() else '+'
              return s


      def fmt_clock(ms):
          ms = max(0, ms)
          if ms < 20000:
              return "%d:%04.1f" % (int(ms // 60000), (ms % 60000) / 1000.0)
          s = int(ms // 1000)
          return "%d:%02d" % (s // 60, s % 60)


      class BoardWidget(QtWidgets.QWidget):
          LIGHT = QtGui.QColor('#ebecd0')
          DARK = QtGui.QColor('#739552')

          def __init__(self, g):
              super().__init__()
              self.g = g
              self.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Expanding)
              self.setMinimumSize(320, 320)
              self.drag = False
              self.drag_pos = None
              self.press_sq = None
              self.cache = {}

          def geom(self):
              s = min(self.width(), self.height())
              return (self.width() - s) / 2.0, (self.height() - s) / 2.0, s / 8.0

          def disp(self, r, c):
              return (7 - r, 7 - c) if self.g.flipped else (r, c)

          def sq_at(self, x, y):
              ox, oy, cell = self.geom()
              dc = int((x - ox) // cell)
              dr = int((y - oy) // cell)
              if not (0 <= dr < 8 and 0 <= dc < 8):
                  return None
              return (7 - dr, 7 - dc) if self.g.flipped else (dr, dc)

          def piece_path(self, piece, cell):
              key = (piece, int(cell))
              if key in self.cache:
                  return self.cache[key]
              glyph = {'k': '\u265A', 'q': '\u265B', 'r': '\u265C',
                       'b': '\u265D', 'n': '\u265E', 'p': '\u265F'}[piece.lower()]
              f = QtGui.QFont()
              fam = ['DejaVu Sans', 'Segoe UI Symbol', 'Noto Sans Symbols2', 'FreeSerif', 'Arial Unicode MS']
              if hasattr(f, 'setFamilies'):
                  f.setFamilies(fam)
              else:
                  f.setFamily(fam[0])
              f.setPixelSize(max(8, int(cell * 0.80)))
              path = QtGui.QPainterPath()
              path.addText(0, 0, f, glyph)
              if path.isEmpty():
                  path.addText(0, 0, f, piece.upper())
              br = path.boundingRect()
              path.translate(-br.center().x(), -br.center().y())
              self.cache[key] = path
              return path

          def draw_piece(self, p, piece, cx, cy, cell):
              path = self.piece_path(piece, cell)
              p.save()
              p.translate(cx, cy)
              if piece.isupper():
                  p.setBrush(QtGui.QColor('#ffffff'))
                  p.setPen(QtGui.QPen(QtGui.QColor('#2a2a2a'), max(1.0, cell * 0.03)))
              else:
                  p.setBrush(QtGui.QColor('#262626'))
                  p.setPen(QtGui.QPen(QtGui.QColor('#000000'), max(1.0, cell * 0.02)))
              p.drawPath(path)
              p.restore()

          def paintEvent(self, ev):
              g = self.g
              p = QtGui.QPainter(self)
              p.setRenderHint(QtGui.QPainter.Antialiasing)
              p.setRenderHint(QtGui.QPainter.TextAntialiasing)
              ox, oy, cell = self.geom()
              board = g.pos.board
              lm = g.last_move
              last_sqs = {(lm[0], lm[1]), (lm[2], lm[3])} if lm else set()
              check_sq = g.pos.find_king(g.pos.turn) if (g.pos.in_check() and g.active) or \
                  (g.pos.in_check() and g.result.startswith('Checkmate')) else None
              targets = {(m[2], m[3]) for m in g.targets}
              font = QtGui.QFont()
              font.setPixelSize(max(8, int(cell * 0.17)))
              font.setBold(True)
              p.setFont(font)
              for r in range(8):
                  for c in range(8):
                      dr, dc = self.disp(r, c)
                      rect = QtCore.QRectF(ox + dc * cell, oy + dr * cell, cell, cell)
                      light = (r + c) % 2 == 0
                      p.fillRect(rect, self.LIGHT if light else self.DARK)
                      if (r, c) in last_sqs:
                          p.fillRect(rect, QtGui.QColor(255, 235, 0, 105))
                      if g.selected == (r, c):
                          p.fillRect(rect, QtGui.QColor(255, 235, 0, 140))
                      if check_sq == (r, c):
                          grad = QtGui.QRadialGradient(rect.center(), cell * 0.62)
                          grad.setColorAt(0.0, QtGui.QColor(255, 0, 0, 220))
                          grad.setColorAt(1.0, QtGui.QColor(255, 0, 0, 0))
                          p.fillRect(rect, QtGui.QBrush(grad))
                      p.setPen(self.DARK if light else self.LIGHT)
                      if dc == 0:
                          p.drawText(rect.adjusted(cell * 0.05, cell * 0.03, 0, 0),
                                     QtCore.Qt.AlignLeft | QtCore.Qt.AlignTop, str(8 - r))
                      if dr == 7:
                          p.drawText(rect.adjusted(0, 0, -cell * 0.06, -cell * 0.03),
                                     QtCore.Qt.AlignRight | QtCore.Qt.AlignBottom, FILES[c])
              for r in range(8):
                  for c in range(8):
                      piece = board[r][c]
                      if piece == '.':
                          continue
                      if self.drag and g.selected == (r, c):
                          continue
                      dr, dc = self.disp(r, c)
                      self.draw_piece(p, piece, ox + (dc + 0.5) * cell, oy + (dr + 0.5) * cell, cell)
              p.setPen(QtCore.Qt.NoPen)
              for (r, c) in targets:
                  dr, dc = self.disp(r, c)
                  cx, cy = ox + (dc + 0.5) * cell, oy + (dr + 0.5) * cell
                  if board[r][c] == '.' and not any(m[2] == r and m[3] == c and m[0] != m[2] and
                                                    board[m[0]][m[1]].upper() == 'P' and m[1] != m[3]
                                                    for m in g.targets):
                      p.setBrush(QtGui.QColor(0, 0, 0, 55))
                      p.drawEllipse(QtCore.QPointF(cx, cy), cell * 0.16, cell * 0.16)
                  else:
                      p.setBrush(QtCore.Qt.NoBrush)
                      p.setPen(QtGui.QPen(QtGui.QColor(0, 0, 0, 55), cell * 0.09))
                      p.drawEllipse(QtCore.QPointF(cx, cy), cell * 0.42, cell * 0.42)
                      p.setPen(QtCore.Qt.NoPen)
              if self.drag and g.selected and self.drag_pos is not None:
                  sr, sc = g.selected
                  self.draw_piece(p, board[sr][sc], self.drag_pos.x(), self.drag_pos.y(), cell)
              p.end()

          def mousePressEvent(self, e):
              if e.button() != QtCore.Qt.LeftButton:
                  return
              sq = self.sq_at(e.x(), e.y())
              self.press_sq = sq
              if sq is None:
                  return
              self.g.click(*sq)
              if self.g.selected == sq:
                  self.drag = True
                  self.drag_pos = e.pos()
              self.update()

          def mouseMoveEvent(self, e):
              if self.drag:
                  self.drag_pos = e.pos()
                  self.update()

          def mouseReleaseEvent(self, e):
              if self.drag:
                  self.drag = False
                  sq = self.sq_at(e.x(), e.y())
                  if sq is not None and sq != self.press_sq:
                      self.g.click(*sq)
              self.update()


      class PlayerBar(QtWidgets.QFrame):
          def __init__(self):
              super().__init__()
              lay = QtWidgets.QHBoxLayout(self)
              lay.setContentsMargins(10, 6, 10, 6)
              self.name = QtWidgets.QLabel('')
              self.name.setStyleSheet("font-weight:bold;background:transparent;")
              self.clock = QtWidgets.QLabel('0:00')
              self.clock.setAlignment(QtCore.Qt.AlignRight | QtCore.Qt.AlignVCenter)
              self.clock.setStyleSheet("font-size:26px;font-weight:bold;font-family:monospace;background:transparent;")
              lay.addWidget(self.name, 1)
              lay.addWidget(self.clock)
              self.set_active(False)

          def set_active(self, on):
              self.setStyleSheet("QFrame{background:%s;border-radius:4px;}" % ('#ffffff' if on else '#262421'))
              col = '#000000' if on else '#bbbbbb'
              self.name.setStyleSheet("font-weight:bold;background:transparent;color:%s;" % col)
              self.clock.setStyleSheet("font-size:26px;font-weight:bold;font-family:monospace;"
                                       "background:transparent;color:%s;" % col)


      class ChessWindow(QtWidgets.QWidget):
          def __init__(self, g):
              super().__init__()
              self.g = g
              self.setWindowTitle("Radio Chess | Node %s vs %s" % (g.my_addr, g.peer_addr))
              self.resize(1150, 800)
              self.setMinimumSize(760, 560)
              self.setStyleSheet(
                  "QWidget{background:#312e2b;color:#ffffff;font-size:14px;}"
                  "QPushButton{background:#454240;border:none;padding:9px 12px;border-radius:4px;font-weight:bold;}"
                  "QPushButton:hover{background:#5a5755;}"
                  "QComboBox{background:#454240;padding:5px;border-radius:4px;}"
                  "QComboBox QAbstractItemView{background:#262421;selection-background-color:#739552;}"
                  "QTextBrowser{background:#262421;border:none;}"
                  "QLineEdit{background:#262421;border:none;border-radius:4px;padding:7px;}")
              root = QtWidgets.QHBoxLayout(self)
              root.setContentsMargins(12, 12, 12, 12)
              root.setSpacing(12)
              self.board = BoardWidget(g)
              root.addWidget(self.board, 1)
              panel = QtWidgets.QWidget()
              panel.setMinimumWidth(270)
              panel.setMaximumWidth(360)
              v = QtWidgets.QVBoxLayout(panel)
              v.setContentsMargins(0, 0, 0, 0)
              self.top = PlayerBar()
              self.bottom = PlayerBar()
              self.moves = QtWidgets.QTextBrowser()
              self.chat_view = QtWidgets.QTextBrowser()
              self.chat_input = QtWidgets.QLineEdit()
              self.chat_input.setPlaceholderText("Chat with opponent (Enter to send)")
              self.chat_input.setMaxLength(500)
              self.chat_input.returnPressed.connect(self.on_chat_send)
              b_send = QtWidgets.QPushButton("Send")
              b_send.clicked.connect(self.on_chat_send)
              chat_row = QtWidgets.QHBoxLayout()
              chat_row.addWidget(self.chat_input, 1)
              chat_row.addWidget(b_send)
              self.status = QtWidgets.QLabel('')
              self.status.setWordWrap(True)
              self.info = QtWidgets.QLabel('')
              self.info.setWordWrap(True)
              self.info.setStyleSheet("color:#aaaaaa;font-size:12px;")
              self.tc_combo = QtWidgets.QComboBox()
              for name, b, i in TCS:
                  self.tc_combo.addItem(name)
              idx = next((k for k, t in enumerate(TCS) if t[1] == g.base and t[2] * 1000 == g.inc), -1)
              if idx < 0:
                  self.tc_combo.addItem("Custom %g+%d" % (g.base / 60.0, g.inc // 1000))
                  idx = self.tc_combo.count() - 1
                  self.custom = (g.base, g.inc // 1000)
              else:
                  self.custom = None
              self.tc_combo.setCurrentIndex(idx)
              self.color_combo = QtWidgets.QComboBox()
              self.color_combo.addItems(["Play as White", "Play as Black", "Random"])
              self.color_combo.setCurrentIndex(0 if g.my_color == 'w' else 1)
              b_new = QtWidgets.QPushButton("New Game")
              b_res = QtWidgets.QPushButton("Resign")
              b_flip = QtWidgets.QPushButton("Flip Board")
              b_draw = QtWidgets.QPushButton("Offer Draw")
              b_take = QtWidgets.QPushButton("Takeback")
              b_draw.clicked.connect(lambda: g.request('draw_offer'))
              b_take.clicked.connect(lambda: g.request('takeback_req'))
              b_new.clicked.connect(self.on_new)
              b_res.clicked.connect(g.resign)
              b_flip.clicked.connect(self.on_flip)
              v.addWidget(self.top)
              v.addWidget(self.moves, 3)
              v.addWidget(self.chat_view, 2)
              v.addLayout(chat_row)
              v.addWidget(self.bottom)
              v.addWidget(self.status)
              v.addWidget(self.tc_combo)
              v.addWidget(self.color_combo)
              row = QtWidgets.QHBoxLayout()
              row.addWidget(b_new)
              row.addWidget(b_res)
              row.addWidget(b_flip)
              v.addLayout(row)
              row2 = QtWidgets.QHBoxLayout()
              row2.addWidget(b_draw)
              row2.addWidget(b_take)
              v.addLayout(row2)
              v.addWidget(self.info)
              root.addWidget(panel, 0)

          def on_new(self):
              i = self.tc_combo.currentIndex()
              if i < len(TCS):
                  base, inc = TCS[i][1], TCS[i][2]
              else:
                  base, inc = self.custom
              c = self.color_combo.currentIndex()
              color = 'w' if c == 0 else 'b' if c == 1 else random.choice('wb')
              self.g.new_game(color, base, inc)

          def on_chat_send(self):
              text = self.chat_input.text()
              self.chat_input.clear()
              self.g.send_chat(text)

          def update_chat(self):
              rows = []
              for m in self.g.chat_log[-60:]:
                  t = _html.escape(m['text'])
                  if m['who'] == 'me':
                      st = ("<span style='color:#888;font-size:11px'> (%s)</span>" % _html.escape(m['status'])) if m['status'] else ''
                      rows.append("<p style='margin:2px'><b style='color:#9ccc65'>You:</b> %s%s</p>" % (t, st))
                  elif m['who'] == 'peer':
                      rows.append("<p style='margin:2px'><b style='color:#64b5f6'>%s:</b> %s</p>" % (_html.escape(m.get('tag', 'Opponent')), t))
                  else:
                      rows.append("<p style='margin:2px;color:#888'><i>%s</i></p>" % t)
              self.chat_view.setHtml(''.join(rows))
              sb = self.chat_view.verticalScrollBar()
              sb.setValue(sb.maximum())

          def on_flip(self):
              self.g.flipped = not self.g.flipped
              self.refresh()

          def sync_combos(self):
              for k, t in enumerate(TCS):
                  if t[1] == self.g.base and t[2] * 1000 == self.g.inc:
                      self.tc_combo.setCurrentIndex(k)
                      break
              self.color_combo.setCurrentIndex(0 if self.g.my_color == 'w' else 1)

          def refresh(self):
              g = self.g
              self.board.update()
              bottom_c = 'b' if g.flipped else 'w'
              top_c = 'w' if g.flipped else 'b'
              for bar, col in ((self.top, top_c), (self.bottom, bottom_c)):
                  who = ("You (%s)" % g.my_addr) if col == g.my_color else ("Opponent (%s)" % g.peer_addr)
                  bar.name.setText("%s — %s" % (who, 'White' if col == 'w' else 'Black'))
              rows = []
              for i in range(0, len(g.sans), 2):
                  w = g.sans[i]
                  b = g.sans[i + 1] if i + 1 < len(g.sans) else ''
                  rows.append("<tr><td style='color:#888'>%d.&nbsp;</td><td><b>%s</b>&nbsp;&nbsp;</td>"
                              "<td><b>%s</b></td></tr>" % (i // 2 + 1, w, b))
              res = ("<p style='color:#ffd54f'><b>%s</b></p>" % g.result) if g.result else ''
              self.moves.setHtml("<table cellspacing='4'>%s</table>%s" % (''.join(rows), res))
              sb = self.moves.verticalScrollBar()
              sb.setValue(sb.maximum())
              self.status.setText(g.status_text())
              self.info.setText("%s | You: %s | %s" % (g.tc_label(), 'White' if g.my_color == 'w' else 'Black',
                                                        "Loopback test: both sides playable here" if g.echo_test
                                                        else "Radio link: you move your colour only"))
              self.update_clocks()

          def update_clocks(self):
              g = self.g
              bottom_c = 'b' if g.flipped else 'w'
              top_c = 'w' if g.flipped else 'b'
              running = g.active and len(g.history) >= 2
              for bar, col in ((self.top, top_c), (self.bottom, bottom_c)):
                  bar.clock.setText(fmt_clock(g.clock[col]))
                  bar.set_active(running and g.pos.turn == col)


      class blk(gr.basic_block):
          def __init__(self, my_addr='A', peer_addr='B', time_control='5+0', color_choice='white',
                       show_gui=True, echo_test=True):
              gr.basic_block.__init__(self, name='Chess GUI', in_sig=None, out_sig=None)
              self.my_addr = str(my_addr)
              self.peer_addr = str(peer_addr)
              self.show_gui = show_gui
              self.echo_test = bool(echo_test)
              self.message_port_register_in(pmt.intern('event_in'))
              self.set_msg_handler(pmt.intern('event_in'), self.handle_event)
              self.message_port_register_out(pmt.intern('command_out'))
              self.message_port_register_in(pmt.intern('chat_in'))
              self.set_msg_handler(pmt.intern('chat_in'), self.handle_chat_event)
              self.message_port_register_out(pmt.intern('chat_out'))
              self.events = []
              self.chat_events = []
              self.chat_log = []
              self.chat_queue = []
              self.chat_busy = False
              self.chat_pending = {}
              self.chat_id = 0
              try:
                  a, b = str(time_control).split('+')
                  base, inc = int(float(a) * 60), int(float(b))
              except Exception:
                  base, inc = 300, 0
              cc = str(color_choice).lower()
              my = 'w' if cc.startswith('w') else 'b' if cc.startswith('b') else random.choice('wb')
              self.window = None
              self.pending_new = None
              self.pending_move = None
              self.start_game(my, base, inc, int(time.time() * 1000) % 1000000000)
              if self.show_gui:
                  self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])
                  self.window = ChessWindow(self)
                  self.window.show()
                  self.window.refresh()
                  self.timer = QtCore.QTimer()
                  self.timer.timeout.connect(self.on_tick)
                  self.timer.start(100)

          # ---------------- game state ----------------
          def start_game(self, my_color, base, inc, gid):
              self.pos = Position()
              self.history = []
              self.sans = []
              self.reps = {self.pos.key(): 1}
              self.base = base
              self.inc = inc * 1000
              self.clock = {'w': base * 1000.0, 'b': base * 1000.0}
              self.active = True
              self.result = ''
              self.last_move = None
              self.selected = None
              self.targets = []
              self.legal_cache = self.pos.legal()
              self.my_color = my_color
              self.flipped = (my_color == 'b')
              self.gid = gid
              self.pending_new = None
              self.pending_move = None
              self.snapshots = []
              self.epoch = 0
              self.pending_req = None
              self.note = ''
              self.answered = {}
              self.asking = False
              self.last_tick = time.monotonic()
              if self.window:
                  self.window.refresh()

          def tc_label(self):
              return "Time Control: %g+%d" % (self.base / 60.0, self.inc // 1000)

          def new_game(self, my_color, base, inc):
              gid = int(time.time() * 1000) % 1000000000
              self.start_game(my_color, base, inc, gid)
              if not self.echo_test:
                  pk = {'type': 'new_game', 'gid': gid, 'host_color': my_color, 'base': base, 'inc': inc}
                  self.pending_new = (pk, time.monotonic())
                  self.send(pk)

          def can_move(self, color):
              return self.echo_test or color == self.my_color

          def status_text(self):
              if self.result:
                  return self.result
              s = ("White" if self.pos.turn == 'w' else "Black") + " to move"
              if self.pos.in_check():
                  s += " — CHECK!"
              if not self.echo_test:
                  s += "  (your turn)" if self.pos.turn == self.my_color else "  (waiting for opponent)"
              if len(self.history) < 2:
                  s += "\nClocks start after both sides have moved."
              if self.note:
                  s += "\n" + self.note
              return s

          def finish(self, text):
              self.active = False
              self.result = text
              self.selected = None
              self.targets = []

          def check_end(self):
              if not self.legal_cache:
                  if self.pos.in_check():
                      self.finish("Checkmate — %s wins" % ("Black" if self.pos.turn == 'w' else "White"))
                  else:
                      self.finish("Draw by stalemate")
              elif self.pos.insufficient():
                  self.finish("Draw by insufficient material")
              elif self.pos.half >= 100:
                  self.finish("Draw by fifty-move rule")
              elif self.reps.get(self.pos.key(), 0) >= 3:
                  self.finish("Draw by threefold repetition")

          def tick(self):
              now = time.monotonic()
              dt = now - self.last_tick
              self.last_tick = now
              if self.active and len(self.history) >= 2:
                  side = self.pos.turn
                  self.clock[side] -= dt * 1000.0
                  if self.clock[side] <= 0:
                      self.clock[side] = 0
                      self.finish("%s wins on time" % ("Black" if side == 'w' else "White"))
                      if self.window:
                          self.window.refresh()

          def apply_move(self, m, net=False):
              if not self.active or m not in self.legal_cache:
                  return False
              self.tick()
              self.snapshots.append((self.pos, self.last_move, dict(self.clock)))
              self.note = ''
              self.pending_req = None
              mover = self.pos.turn
              if len(self.history) >= 2:
                  self.clock[mover] += self.inc
              san = self.pos.san(m, self.legal_cache)
              self.pos = self.pos.make(m)
              self.history.append(uci(m))
              self.sans.append(san)
              k = self.pos.key()
              self.reps[k] = self.reps.get(k, 0) + 1
              self.last_move = m
              self.selected = None
              self.targets = []
              self.legal_cache = self.pos.legal()
              self.check_end()
              if net:
                  self.pending_move = None
              else:
                  self.send_move()
              if self.window:
                  self.window.refresh()
              return True

          def ask_promotion(self, cand):
              menu = QtWidgets.QMenu(self.window)
              acts = {}
              for name, ch in (("Queen", 'q'), ("Rook", 'r'), ("Bishop", 'b'), ("Knight", 'n')):
                  acts[menu.addAction(name)] = ch
              a = menu.exec_(QtGui.QCursor.pos())
              if a is None:
                  return None
              return next((m for m in cand if m[4] == acts[a]), None)

          def click(self, r, c):
              if not self.active:
                  return
              if self.pending_req and self.pending_req['pk']['type'] == 'takeback_req':
                  self.note = 'Waiting for takeback answer...'
                  return
              p = self.pos.board[r][c]
              if self.selected is not None:
                  cand = [m for m in self.targets if m[2] == r and m[3] == c]
                  if cand:
                      m = cand[0] if len(cand) == 1 else self.ask_promotion(cand)
                      if m is not None:
                          self.apply_move(m)
                      if self.window:
                          self.window.refresh()
                      return
              if p != '.' and p.isupper() == (self.pos.turn == 'w') and self.can_move(self.pos.turn):
                  self.selected = (r, c)
                  self.targets = [m for m in self.legal_cache if m[0] == r and m[1] == c]
              else:
                  self.selected = None
                  self.targets = []
              if self.window:
                  self.window.refresh()

          def resign(self):
              if not self.active:
                  return
              side = self.pos.turn if self.echo_test else self.my_color
              self.finish("%s resigned — %s wins" % ("White" if side == 'w' else "Black",
                                                     "Black" if side == 'w' else "White"))
              if not self.echo_test:
                  self.send({'type': 'resign', 'gid': self.gid, 'color': side})
              if self.window:
                  self.window.refresh()

          # ---------------- draw offers / takebacks ----------------
          def undo_to(self, L):
              while len(self.history) > L and self.snapshots:
                  k = self.pos.key()
                  self.reps[k] = self.reps.get(k, 1) - 1
                  self.history.pop()
                  self.sans.pop()
                  self.pos, self.last_move, self.clock = self.snapshots.pop()
              self.legal_cache = self.pos.legal()
              self.selected = None
              self.targets = []
              self.active = True
              self.result = ''
              self.pending_move = None
              self.pending_req = None
              self.last_tick = time.monotonic()

          def takeback_target(self, requester):
              n = len(self.history)
              if n == 0:
                  return None
              L = n - 2 if self.pos.turn == requester else n - 1
              return L if L >= 0 else None

          def ask_user(self, text):
              self.asking = True
              try:
                  box = QtWidgets.QMessageBox
                  return box.question(self.window, "Radio Chess", text,
                                      box.Yes | box.No, box.No) == box.Yes
              finally:
                  self.asking = False
                  self.last_tick = time.monotonic()

          def request(self, kind):
              if not self.active or self.pending_req or self.asking:
                  return
              n = len(self.history)
              by = self.my_color if not self.echo_test else ('b' if self.pos.turn == 'w' else 'w')
              if kind == 'draw_offer' and self.echo_test:
                  by = self.pos.turn
              if kind == 'takeback_req' and self.takeback_target(by) is None:
                  self.note = "Nothing to take back."
                  self.window.refresh()
                  return
              pk = {'type': kind, 'gid': self.gid, 'n': n, 'by': by}
              if self.echo_test:
                  if kind == 'draw_offer':
                      if self.ask_user("%s offers a draw. Accept?" % ("White" if by == 'w' else "Black")):
                          self.finish("Draw by agreement")
                      else:
                          self.note = "Draw declined."
                  else:
                      if self.ask_user("%s asks to take back their last move. Allow?" %
                                       ("White" if by == 'w' else "Black")):
                          self.undo_to(self.takeback_target(by))
                          self.epoch += 1
                      else:
                          self.note = "Takeback declined."
              else:
                  self.pending_req = {'pk': pk, 't': time.monotonic(), 'tries': 0}
                  self.note = "Draw offer sent..." if kind == 'draw_offer' else "Takeback request sent..."
                  self.send(dict(pk))
              self.window.refresh()

          def on_request(self, pk):
              t = pk['type']
              n = pk.get('n')
              key = (t, n, self.epoch)
              if key in self.answered:
                  self.send(dict(self.answered[key]))
                  return
              if self.asking or not self.active or n != len(self.history):
                  return
              by = pk.get('by')
              who = "Your opponent"
              if t == 'draw_offer':
                  ok = self.ask_user("%s offers a draw. Accept?" % who)
                  L = 0
                  if ok:
                      self.finish("Draw by agreement")
              else:
                  L = self.takeback_target(by)
                  ok = False
                  if L is not None:
                      ok = self.ask_user("%s asks to take back their last move. Allow?" % who)
                  if ok:
                      self.undo_to(L)
                      self.epoch += 1
              ans = {'type': 'draw_ans' if t == 'draw_offer' else 'takeback_ans', 'gid': self.gid,
                     'n': n, 'ok': bool(ok), 'L': L if L is not None else 0}
              self.answered[key] = ans
              self.send(dict(ans))
              self.window.refresh()

          def on_answer(self, pk):
              pr = self.pending_req
              want = 'draw_offer' if pk['type'] == 'draw_ans' else 'takeback_req'
              if not pr or pr['pk']['type'] != want or pk.get('gid') != self.gid or pk.get('n') != pr['pk']['n']:
                  return
              self.pending_req = None
              if pk.get('ok'):
                  if want == 'draw_offer':
                      self.finish("Draw by agreement")
                  elif len(self.history) == pk['n']:
                      self.undo_to(int(pk.get('L', 0)))
                      self.epoch += 1
                      self.note = "Takeback accepted."
              else:
                  self.note = "Opponent declined the %s." % ("draw offer" if want == 'draw_offer' else "takeback")
              self.window.refresh()

          # ---------------- radio side ----------------
          def send(self, d):
              d['chess'] = 1
              d['src'] = self.my_addr
              d['dst'] = self.peer_addr
              raw = json.dumps(d, separators=(',', ':')).encode('utf-8')
              try:
                  self.message_port_pub(pmt.intern('command_out'),
                                        pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              except Exception:
                  pass

          def send_move(self):
              n = len(self.history)
              start = max(0, n - 8)
              pk = {'type': 'move', 'gid': self.gid, 'start': start, 'moves': self.history[start:], 'ep': self.epoch,
                    'clock': [int(self.clock['w']), int(self.clock['b'])]}
              if not self.echo_test:
                  self.pending_move = (pk, n, time.monotonic())
              self.send(pk)

          @staticmethod
          def _bytes(msg):
              if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):
                  return bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              return None

          def handle_event(self, msg):
              raw = self._bytes(msg)
              if raw is None:
                  return
              try:
                  ev = json.loads(raw.decode('utf-8'))
                  if ev.get('direction') == 'peer_move':
                      self.events.append(ev.get('data', {}))
              except ValueError:
                  pass

          def on_packet(self, pk):
              if (self.echo_test and isinstance(pk, dict) and pk.get('chess') == 1 and pk.get('type') == 'chat'
                      and pk.get('src') == self.my_addr and pk.get('dst') == self.peer_addr):
                  self.on_loopback_chat(pk)
                  return
              if not isinstance(pk, dict) or pk.get('chess') != 1 or pk.get('src') == self.my_addr \
                      or pk.get('dst') != self.my_addr:
                  return
              t = pk.get('type')
              if t == 'new_game':
                  gid = pk.get('gid')
                  if gid != self.gid:
                      mine = 'b' if pk.get('host_color') == 'w' else 'w'
                      self.start_game(mine, int(pk.get('base', 300)), int(pk.get('inc', 0)), gid)
                      if self.window:
                          self.window.sync_combos()
                          self.window.refresh()
                  self.send({'type': 'ack_new', 'gid': gid})
              elif t == 'ack_new':
                  if self.pending_new and self.pending_new[0]['gid'] == pk.get('gid'):
                      self.pending_new = None
              elif t == 'ack_move':
                  if (self.pending_move and pk.get('gid') == self.gid
                          and pk.get('n', 0) >= self.pending_move[1]):
                      self.pending_move = None
              elif t == 'resign':
                  if pk.get('gid') == self.gid and self.active:
                      s = pk.get('color')
                      self.finish("%s resigned — %s wins" % ("White" if s == 'w' else "Black",
                                                             "Black" if s == 'w' else "White"))
                      if self.window:
                          self.window.refresh()
              elif t in ('draw_offer', 'takeback_req'):
                  if pk.get('gid') == self.gid:
                      self.on_request(pk)
              elif t in ('draw_ans', 'takeback_ans'):
                  self.on_answer(pk)
              elif t == 'move':
                  if pk.get('gid') != self.gid or pk.get('ep', 0) != self.epoch:
                      return
                  start = pk.get('start', 0)
                  moves = pk.get('moves', [])
                  n = len(self.history)
                  if start <= n < start + len(moves) and self.history[start:n] == moves[:n - start]:
                      for u in moves[n - start:]:
                          m = next((x for x in self.legal_cache if uci(x) == u), None)
                          if m is None:
                              break
                          self.apply_move(m, net=True)
                      clk = pk.get('clock')
                      if clk and len(clk) == 2:
                          self.clock = {'w': float(clk[0]), 'b': float(clk[1])}
                          self.last_tick = time.monotonic()
                  self.send({'type': 'ack_move', 'gid': self.gid, 'n': len(self.history)})

          # ---------------- text chat (via Transfer Protocol) ----------------
          def handle_chat_event(self, msg):
              raw = self._bytes(msg)
              if raw is None:
                  return
              try:
                  ev = json.loads(raw.decode('utf-8'))
                  if isinstance(ev, dict):
                      self.chat_events.append(ev)
              except ValueError:
                  pass

          def send_chat(self, text):
              text = text.strip()[:500]
              if not text:
                  return
              entry = {'who': 'me', 'text': text, 'status': 'queued'}
              self.chat_log.append(entry)
              if self.echo_test:
                  # Loopback test: send over the chess channel (encrypt -> CRC -> RS -> QPSK -> channel
                  # model -> receiver). The echo coming back proves the whole chain works.
                  self.chat_id += 1
                  entry['status'] = 'sending over radio loopback...'
                  self.chat_pending[self.chat_id] = (entry, time.monotonic())
                  self.send({'type': 'chat', 'id': self.chat_id, 'text': text})
              else:
                  self.chat_queue.append(entry)
                  self.pump_chat()
              self.refresh_chat()

          def pump_chat(self):
              if self.chat_busy or not self.chat_queue:
                  return
              entry = self.chat_queue[0]
              entry['status'] = 'sending...'
              self.chat_busy = True
              raw = json.dumps({'cmd': 'send', 'kind': 'text', 'value': entry['text']}).encode('utf-8')
              try:
                  self.message_port_pub(pmt.intern('chat_out'),
                                        pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              except Exception:
                  pass

          def on_chat_event(self, e):
              d = e.get('direction')
              st = str(e.get('state', ''))
              kind = e.get('kind')
              active = st.startswith(('Sending', 'Receiving', 'Waiting', 'Retry'))
              if d == 'rx':
                  if st.startswith('Complete'):
                      if kind == 'text':
                          self.chat_log.append({'who': 'peer', 'text': str(e.get('text', '')), 'status': ''})
                      else:
                          self.chat_log.append({'who': 'sys', 'text': '[peer sent %s: saved to receive folder]' % kind,
                                                'status': ''})
              elif d in ('tx', 'notice'):
                  if d == 'tx' and (kind not in (None, 'text') or active):
                      return
                  if self.chat_busy and self.chat_queue:
                      entry = self.chat_queue.pop(0)
                      entry['status'] = ('delivered \u2713' if (d == 'tx' and st.startswith('Complete'))
                                         else 'failed: ' + st)
                      self.chat_busy = False
                      self.pump_chat()
              self.refresh_chat()

          def on_loopback_chat(self, pk):
              got = self.chat_pending.pop(pk.get('id'), None)
              if got is None:
                  return
              entry, t0 = got
              entry['status'] = 'delivered \u2713 via radio loopback, %.1f s' % (time.monotonic() - t0)
              self.chat_log.append({'who': 'peer', 'text': str(pk.get('text', '')),
                                    'status': '', 'tag': 'Opponent (loopback echo)'})
              self.refresh_chat()

          def refresh_chat(self):
              if self.window:
                  self.window.update_chat()

          def on_tick(self):
              while self.events and not self.asking:
                  self.on_packet(self.events.pop(0))
              while self.chat_events:
                  self.on_chat_event(self.chat_events.pop(0))
              self.tick()
              now = time.monotonic()
              if self.pending_new and now - self.pending_new[1] > 2.0:
                  self.pending_new = (self.pending_new[0], now)
                  self.send(dict(self.pending_new[0]))
              if self.pending_move and now - self.pending_move[2] > 3.0:
                  pk, n, _ = self.pending_move
                  self.pending_move = (pk, n, now)
                  self.send(dict(pk))
              for cid, (ent, t0) in list(self.chat_pending.items()):
                  if now - t0 > 10.0:
                      ent['status'] = 'no echo after 10 s: is the radio chain connected?'
                      del self.chat_pending[cid]
                      self.refresh_chat()
              pr = self.pending_req
              if pr and now - pr['t'] > 3.0:
                  pr['t'] = now
                  pr['tries'] += 1
                  if pr['tries'] > 10:
                      self.pending_req = None
                      self.note = 'No response from opponent.'
                  else:
                      self.send(dict(pr['pk']))
              if self.window:
                  self.window.update_clocks()
                  self.window.status.setText(self.status_text())
    color_choice: '''white'''
    my_addr: my_addr
    peer_addr: peer_addr
    show_gui: 'True'
    time_control: '''5+0'''
    echo_test: 'True'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """Add a repeatable prefix and a tail outside the packet header and payload."""

      import hashlib
      import os

      from gnuradio import gr
      import pmt


      def training_bytes(length):
          output = bytearray()
          counter = 0

          while len(output) < length:
              output.extend(
                  hashlib.sha256(
                      b"QPSK-training-v1" + counter.to_bytes(4, "big")
                  ).digest()
              )
              counter += 1

          return bytes(output[:length])


      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=1500, num_tail_bytes=1024):
              gr.basic_block.__init__(
                  self,
                  name="Burst Prefix + Tail",
                  in_sig=None,
                  out_sig=None,
              )

              self.prefix = int(num_dummy_bytes)
              self.tail = int(num_tail_bytes)

              if self.prefix < 0 or self.tail < 0:
                  raise ValueError("Padding lengths must be nonnegative")

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  return

              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              padded = (
                  training_bytes(self.prefix)
                  + raw
                  + os.urandom(self.tail)
              )

              output = pmt.cons(
                  pmt.car(msg),
                  pmt.init_u8vector(len(padded), list(padded)),
              )
              self.message_port_pub(pmt.intern("pdu_out"), output)
    comment: Random prefix for acquisition; tail flushes finite bursts
    num_dummy_bytes: '2048'
    num_tail_bytes: '2570'
  states: {}
- name: epy_interval_profiles
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: interval profiles for text, image and audio.
      Connect config_out to Transfer Protocol.config_in.
      """
      import json
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, text=0.05, image=0.08, audio=0.08):
              gr.basic_block.__init__(self, name='Interval Profiles',
                                      in_sig=None, out_sig=None)
              self.values = {'text': float(text), 'image': float(image),
                             'audio': float(audio)}
              for value in self.values.values():
                  if not (0, 5)[0] <= value <= (0, 5)[1]:
                      raise ValueError('interval must be within (0, 5)')
              self.message_port_register_out(pmt.intern('config_out'))

          def start(self):
              raw = json.dumps({'category': 'interval', 'values': self.values}).encode('utf-8')
              self.message_port_pub(pmt.intern('config_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              return True
    audio: '0.0625'
    image: '0.0625'
    text: '0.05'
  states: {state: disabled}
- name: epy_rs_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Inverse of rs_packet_encoder.py. Reassemble a complete PDU before CRC Check.
      A failed codeword drops the entire PDU; the existing ARQ retries the packet.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Correct each RS codeword, then emit the original encrypted frame plus CRC."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Decoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096
              self.max_coded = self.max_input + self.nsym * ((self.max_input+self.k-1)//self.k)
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.rx_count = self.fail_count = self.decoded_count = 0
              self.corrected_packets = self.corrected_bytes = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.message_port_register_out(pmt.intern('fail'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  if self.verbose:
                      print('[RS RX] DROP: expected a packed-byte PDU', flush=True)
                  return
              self.rx_count += 1
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              corrected, corrected_bits, nwords = 0, 0, 0
              try:
                  if self.enabled:
                      if not self.nsym+4 <= len(raw) <= self.max_coded:
                          raise ValueError('invalid coded packet length')
                      tail = len(raw) % 255
                      if tail and tail <= self.nsym:
                          raise ValueError('truncated final RS codeword')
                      parts = []
                      for i in range(0, len(raw), 255):
                          received_word = raw[i:i+255]
                          data, repaired_word, positions = self.rs.decode(received_word)
                          parts.append(bytes(data))
                          corrected += sum(a != b for a, b in zip(received_word, repaired_word))
                          corrected_bits += sum(bin(a ^ b).count('1') for a, b in zip(received_word, repaired_word))
                          nwords += 1
                      decoded = b''.join(parts)
                  else:
                      decoded = raw
                  if not 4 <= len(decoded) <= self.max_input:
                      raise ValueError('invalid decoded packet length')
              except (ReedSolomonError, ValueError) as exc:
                  self.fail_count += 1
                  self.message_port_pub(pmt.intern('fail'), msg)
                  if self.verbose:
                      print(f'[RS RX #{self.rx_count}] DROP: {exc}; '
                            f'RS failures={self.fail_count}; waiting for ARQ retry', flush=True)
                  return
              meta = pmt.car(msg)
              if not pmt.is_dict(meta):
                  meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bytes'), pmt.from_long(corrected))
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bits'), pmt.from_long(corrected_bits))
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(decoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(decoded), list(decoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.decoded_count += 1
              self.corrected_packets += int(corrected > 0)
              self.corrected_bytes += corrected
              if self.verbose and (corrected or self.rx_count == 1 or
                                   self.rx_count % self.log_every == 0):
                  print(f'[RS RX #{self.rx_count}] {len(raw)} -> {len(decoded)} bytes; '
                        f'codewords={nwords}; corrected bytes={corrected}; '
                        'CRC/authentication/file verification follow', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS RX SUMMARY] received={self.rx_count}; decoded={self.decoded_count}; '
                        f'RS failures={self.fail_count}; corrected packets={self.corrected_packets}; '
                        f'corrected bytes={self.corrected_bytes}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: epy_rs_encoder
  id: epy_block
  parameters:
    _source_code: |
      """Multi-codeword RS FEC for encrypted transceiver PDUs, including CRC32.
      Each 239-byte segment gets 16 parity bytes at nsym=16. No extra wire header.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Encode all packet types (DATA, metadata, ACK and other controls)."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Encoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096  # Existing 4092-byte encrypted PDU budget + CRC32.
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.tx_count = self.reject_count = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: expected a packed-byte PDU', flush=True)
                  return
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              if not 4 <= len(raw) <= self.max_input:
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: packet must be 4..4096 bytes including CRC', flush=True)
                  return
              if self.enabled:
                  # Explicit boundaries prevent accidental changes to chunking conventions.
                  chunks = [bytes(self.rs.encode(raw[i:i+self.k]))
                            for i in range(0, len(raw), self.k)]
                  encoded = b''.join(chunks)
                  nwords = len(chunks)
              else:
                  encoded, nwords = raw, 0
              meta = pmt.car(msg)
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(encoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(encoded), list(encoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.tx_count += 1
              if self.verbose and (self.tx_count == 1 or self.tx_count % self.log_every == 0):
                  print(f'[RS TX #{self.tx_count}] {len(raw)} -> {len(encoded)} bytes; '
                        f'codewords={nwords}; FEC={self.enabled}', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS TX SUMMARY] packets={self.tx_count}; rejected={self.reject_count}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: epy_size_profiles
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: size profiles for text, image and audio.
      Connect config_out to Transfer Protocol.config_in.
      """
      import json
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, text=128, image=512, audio=512):
              gr.basic_block.__init__(self, name='Size Profiles',
                                      in_sig=None, out_sig=None)
              self.values = {'text': int(text), 'image': int(image),
                             'audio': int(audio)}
              for value in self.values.values():
                  if not (128, 1024)[0] <= value <= (128, 1024)[1]:
                      raise ValueError('size must be within (128, 1024)')
              self.message_port_register_out(pmt.intern('config_out'))

          def start(self):
              raw = json.dumps({'category': 'size', 'values': self.values}).encode('utf-8')
              self.message_port_pub(pmt.intern('config_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              return True
    audio: '1024'
    image: '1024'
    text: '128'
  states: {state: disabled}
- name: epy_timeout_profiles
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: timeout profiles for text, image and audio.
      Connect config_out to Transfer Protocol.config_in.
      """
      import json
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, text=3.0, image=3.0, audio=3.0):
              gr.basic_block.__init__(self, name='Timeout Profiles',
                                      in_sig=None, out_sig=None)
              self.values = {'text': float(text), 'image': float(image),
                             'audio': float(audio)}
              for value in self.values.values():
                  if not (0.05, 30)[0] <= value <= (0.05, 30)[1]:
                      raise ValueError('timeout must be within (0.05, 30)')
              self.message_port_register_out(pmt.intern('config_out'))

          def start(self):
              raw = json.dumps({'category': 'timeout', 'values': self.values}).encode('utf-8')
              self.message_port_pub(pmt.intern('config_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              return True
    audio: '2.0'
    image: '2.0'
    text: '1.0'
  states: {state: disabled}
- name: epy_transfer_chat_gui
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: chat GUI only, with command/event PDU ports."""
      import json
      from pathlib import Path
      import queue
      import threading
      from gnuradio import gr
      import pmt
      from PyQt5 import QtCore, QtGui, QtWidgets


      class _CommandOutput:
          def __init__(self, block):
              self.block = block

          def put_nowait(self, command):
              if command[0] == 'send':
                  value = dict(cmd='send', kind=command[1], value=command[2])
              elif command[0] == 'cancel':
                  value = dict(cmd='cancel')
              else:
                  raise ValueError('Unsupported GUI command')
              raw = json.dumps(value, ensure_ascii=True).encode('utf-8')
              self.block.message_port_pub(pmt.intern('command_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))


      class blk(gr.basic_block):
          """Chat window; protocol work happens in a separate block."""

          def __init__(self, my_addr='A1', peer_addr='B1',
                       receive_dir='./received_A1', show_gui=True):
              gr.basic_block.__init__(self, name='Transfer Chat GUI', in_sig=None, out_sig=None)
              self.my_addr = my_addr
              self.peer_addr = peer_addr
              self.receive_dir = str(Path(receive_dir).expanduser().resolve())
              self.show_gui = bool(show_gui)
              self.commands = _CommandOutput(self)
              self.events = queue.Queue()
              self.halt = threading.Event()
              self.bridge = None
              self.message_port_register_in(pmt.intern('event_in'))
              self.message_port_register_out(pmt.intern('command_out'))
              self.set_msg_handler(pmt.intern('event_in'), self._receive_event)

          def _receive_event(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  return
              try:
                  raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
                  if len(raw) <= 524288:
                      self.events.put_nowait(json.loads(raw.decode('utf-8')))
              except (ValueError, UnicodeError, queue.Full):
                  pass

          def start(self):
              self.halt.clear()
              if self.show_gui:
                  app = QtWidgets.QApplication.instance()
                  if app is None:
                      print('[Transfer GUI] Set Options > Generate Options = QT GUI')
                      return False
                  self.bridge = _WindowBridge(self)
                  self.bridge.moveToThread(app.thread())
                  self.bridge.open_requested.emit()
              return True

          def stop(self):
              self.halt.set()
              if self.bridge:
                  self.bridge.close_requested.emit()
              return True


      class _WindowBridge(QtCore.QObject):
          open_requested = QtCore.pyqtSignal()
          close_requested = QtCore.pyqtSignal()

          def __init__(self, block):
              super().__init__()
              self.block, self.window = block, None
              self.open_requested.connect(self.open_window, QtCore.Qt.QueuedConnection)
              self.close_requested.connect(self.close_window, QtCore.Qt.QueuedConnection)

          @QtCore.pyqtSlot()
          def open_window(self):
              if not self.block.halt.is_set():
                  self.window = _TransferWindow(self.block)
                  self.window.show()

          @QtCore.pyqtSlot()
          def close_window(self):
              if self.window:
                  self.window.timer.stop()
                  self.window.allow_close = True
                  self.window.close()
                  self.window.deleteLater()
                  self.window = None


      class _TransferWindow(QtWidgets.QWidget):
          """Chat view only. Packet handling stays in _TransferCore."""
          def __init__(self, block):
              super().__init__()
              self.block, self.allow_close = block, False
              self.tx_bubble = self.rx_bubble = None
              self.messages = []
              self.setWindowTitle('Chat | %s → %s' % (block.my_addr, block.peer_addr))
              self.resize(570, 780)
              self.setMinimumSize(440, 540)
              self.setStyleSheet('''
                  QWidget { color:#173b32; font-family:Sans; font-size:14px; }
                  QWidget#chat, QWidget#historyBody { background:#f3f1eb; }
                  QFrame#header, QFrame#composer { background:white; }
                  QLabel { background:transparent; }
                  QLabel#avatar { background:#128c7e; color:white; border-radius:23px;
                      font-size:18px; font-weight:600; }
                  QLabel#name { font-size:18px; font-weight:600; }
                  QLabel#secondary { color:#77847e; font-size:11px; }
                  QLabel#day { color:#7b8780; font-size:11px; padding:10px; }
                  QFrame#sent { background:#d9fdd3; border:1px solid #ccecc6; border-radius:14px; }
                  QFrame#received { background:white; border:1px solid #e1e6e2; border-radius:14px; }
                  QPlainTextEdit { background:#f4f6f4; border:1px solid #e7ebe7;
                      border-radius:20px; padding:8px; font-size:14px; }
                  QPushButton,QToolButton { background:#e8f3ed; border:0; border-radius:16px;
                      padding:8px 12px; color:#16785c; }
                  QPushButton:hover,QToolButton:hover { background:#d1eadd; }
                  QPushButton#send { background:#128c7e; color:white; font-weight:600; }
                  QToolButton#attach { background:transparent; font-size:28px; padding:0; }
                  QToolButton::menu-indicator { image:none; }
                  QPushButton:disabled,QToolButton:disabled { color:#a4b8ac; background:#e7ede8; }
                  QPushButton#file { background:transparent; text-align:left; padding:5px 0; }
                  QPushButton#cancel { background:transparent; color:#886958; padding:2px; font-size:11px; }
                  QMenu { background:white; border:1px solid #d7e3da; padding:6px; }
                  QMenu::item { padding:9px 22px; }
                  QMenu::item:selected { background:#e6f4eb; }
                  QProgressBar { background:#e7eae1; border:0; border-radius:3px; }
                  QProgressBar::chunk { background:#20a47d; border-radius:3px; }
                  QScrollArea { background:transparent; border:0; }
                  QScrollBar:vertical { width:6px; background:transparent; }
                  QScrollBar::handle:vertical { background:#cdd6cc; border-radius:3px; min-height:24px; }
                  QScrollBar::add-line:vertical,QScrollBar::sub-line:vertical { height:0; }
              ''')
              self.setObjectName('chat')
              root = QtWidgets.QVBoxLayout(self)
              root.setContentsMargins(0, 0, 0, 0)
              root.setSpacing(0)

              header = QtWidgets.QFrame()
              header.setObjectName('header')
              top = QtWidgets.QHBoxLayout(header)
              top.setContentsMargins(20, 16, 18, 16)
              avatar = QtWidgets.QLabel(block.peer_addr)
              avatar.setObjectName('avatar')
              avatar.setAlignment(QtCore.Qt.AlignCenter)
              avatar.setFixedSize(46, 46)
              top.addWidget(avatar)
              contact = QtWidgets.QVBoxLayout()
              contact.setSpacing(4)
              name = QtWidgets.QLabel('Chat with ' + block.peer_addr)
              name.setObjectName('name')
              subtitle = QtWidgets.QLabel('Your node: ' + block.my_addr)
              subtitle.setObjectName('secondary')
              contact.addWidget(name)
              contact.addWidget(subtitle)
              top.addLayout(contact, 1)
              files = QtWidgets.QPushButton('Received files')
              files.clicked.connect(self.open_folder)
              top.addWidget(files)
              root.addWidget(header)

              self.scroll = QtWidgets.QScrollArea()
              self.scroll.setWidgetResizable(True)
              self.scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              body = QtWidgets.QWidget()
              body.setObjectName('historyBody')
              self.history = QtWidgets.QVBoxLayout(body)
              self.history.setContentsMargins(16, 4, 16, 14)
              self.history.setSpacing(12)
              self.history.setSizeConstraint(QtWidgets.QLayout.SetMinAndMaxSize)
              day = QtWidgets.QLabel('TODAY')
              day.setObjectName('day')
              day.setAlignment(QtCore.Qt.AlignCenter)
              self.history.addWidget(day)
              self.history.addStretch(1)
              self.scroll.setWidget(body)
              root.addWidget(self.scroll, 1)

              composer = QtWidgets.QFrame()
              composer.setObjectName('composer')
              controls = QtWidgets.QVBoxLayout(composer)
              controls.setContentsMargins(12, 12, 16, 9)
              row = QtWidgets.QHBoxLayout()
              row.setSpacing(8)
              self.attach = QtWidgets.QToolButton()
              self.attach.setObjectName('attach')
              self.attach.setText('+')
              self.attach.setToolTip('Send an image or audio file')
              self.attach.setAccessibleName('Attach image or audio file')
              self.attach.setFixedSize(38, 44)
              menu = QtWidgets.QMenu(self.attach)
              menu.addAction('Image…', lambda: self.choose('image'))
              menu.addAction('Audio file…', lambda: self.choose('audio'))
              self.attach.setMenu(menu)
              self.attach.setPopupMode(QtWidgets.QToolButton.InstantPopup)
              self.text = QtWidgets.QPlainTextEdit()
              self.text.setPlaceholderText('Type a message…')
              self.text.setFixedHeight(60)
              self.text.installEventFilter(self)
              self.send_button = QtWidgets.QPushButton('Send')
              self.send_button.setObjectName('send')
              self.send_button.setFixedSize(68, 44)
              self.send_button.clicked.connect(self.send_text)
              row.addWidget(self.attach)
              row.addWidget(self.text, 1)
              row.addWidget(self.send_button)
              controls.addLayout(row)
              self.hint = QtWidgets.QLabel('Enter to send · Shift+Enter for a new line')
              self.hint.setObjectName('secondary')
              self.hint.setAlignment(QtCore.Qt.AlignCenter)
              self.hint.setWordWrap(True)
              controls.addWidget(self.hint)
              root.addWidget(composer)
              self.timer = QtCore.QTimer(self)
              self.timer.timeout.connect(self.poll)
              self.timer.start(50)

          def eventFilter(self, obj, event):
              if obj is self.text and event.type() == QtCore.QEvent.KeyPress:
                  if event.key() in (QtCore.Qt.Key_Return, QtCore.Qt.Key_Enter):
                      if not event.modifiers() & QtCore.Qt.ShiftModifier:
                          self.send_text()
                          return True
              return super().eventFilter(obj, event)

          def send_text(self):
              if self.send_button.isEnabled() and self.text.toPlainText().strip():
                  if self.submit('text', self.text.toPlainText()):
                      self.text.clear()

          def choose(self, kind):
              filters = ('Images (*.png *.jpg *.jpeg *.bmp *.gif *.webp);;All files (*)'
                         if kind == 'image' else
                         'Audio (*.wav *.mp3 *.ogg *.flac *.m4a *.aac);;All files (*)')
              path, _ = QtWidgets.QFileDialog.getOpenFileName(self, 'Choose ' + kind + ' to send', '', filters)
              if path:
                  self.submit(kind, path)

          def submit(self, kind, value):
              if self.tx_bubble is not None:
                  return False
              try:
                  self.block.commands.put_nowait(('send', kind, value))
              except queue.Full:
                  self.hint.setText('Please try again in a moment.')
                  return False
              caption = value if kind == 'text' else Path(value).name
              self.tx_bubble = self.add_bubble(True, kind, caption)
              if kind != 'text':
                  self.show_file(self.tx_bubble, value)
              self.set_busy(True)
              return True

          def add_bubble(self, outgoing, kind, caption):
              row = QtWidgets.QWidget()
              layout = QtWidgets.QHBoxLayout(row)
              layout.setContentsMargins(0, 0, 0, 0)
              card = QtWidgets.QFrame()
              card.setObjectName('sent' if outgoing else 'received')
              card.setMaximumWidth(max(260, int(self.width() * 0.73)))
              card.setSizePolicy(QtWidgets.QSizePolicy.Preferred, QtWidgets.QSizePolicy.Maximum)
              content = QtWidgets.QVBoxLayout(card)
              content.setContentsMargins(13, 11, 13, 9)
              content.setSpacing(7)
              label = QtWidgets.QLabel()
              label.setTextFormat(QtCore.Qt.PlainText)
              label.setText(caption[:4096] + ('\n[Preview shortened]' if len(caption) > 4096 else ''))
              label.setWordWrap(True)
              label.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              label.setMinimumWidth(150)
              content.addWidget(label)
              preview = QtWidgets.QLabel()
              preview.setAlignment(QtCore.Qt.AlignCenter)
              preview.hide()
              content.addWidget(preview)
              open_button = QtWidgets.QPushButton('Play audio' if kind == 'audio' else 'Open file')
              open_button.setObjectName('file')
              open_button.hide()
              content.addWidget(open_button)
              progress = QtWidgets.QProgressBar()
              progress.setRange(0, 1000)
              progress.setValue(0)
              progress.setTextVisible(False)
              progress.setFixedHeight(5)
              content.addWidget(progress)
              footer = QtWidgets.QHBoxLayout()
              status = QtWidgets.QLabel('Preparing…' if outgoing else 'Receiving…')
              status.setObjectName('secondary')
              status.setTextFormat(QtCore.Qt.PlainText)
              status.setWordWrap(True)
              footer.addWidget(status, 1)
              cancel = QtWidgets.QPushButton('Cancel')
              cancel.setObjectName('cancel')
              cancel.setVisible(outgoing)
              cancel.clicked.connect(self.cancel_send)
              footer.addWidget(cancel)
              content.addLayout(footer)
              if outgoing:
                  layout.addStretch(1)
              layout.addWidget(card)
              if not outgoing:
                  layout.addStretch(1)
              self.history.insertWidget(self.history.count() - 1, row)
              record = dict(row=row, card=card, label=label, preview=preview, open=open_button,
                            bar=progress, status=status, cancel=cancel, kind=kind,
                            outgoing=outgoing, time=QtCore.QTime.currentTime().toString('HH:mm'),
                            path=None, text=None, state='Preparing', done=0, total=0)
              self.messages.append(record)
              # Bound widget memory; received files remain saved on disk.
              while len(self.messages) > 200:
                  old = next((m for m in self.messages if m is not self.tx_bubble and m is not self.rx_bubble), None)
                  if old is None:
                      break
                  self.messages.remove(old)
                  self.history.removeWidget(old['row'])
                  old['row'].deleteLater()
              QtCore.QTimer.singleShot(0, self.scroll_bottom)
              return record

          def show_file(self, bubble, path):
              bubble['path'] = path
              bubble['open'].setProperty('file_path', path)
              if not bubble.get('open_connected'):
                  bubble['open'].clicked.connect(self.open_file)
                  bubble['open_connected'] = True
              bubble['open'].show()
              if bubble['kind'] == 'image':
                  reader = QtGui.QImageReader(path)
                  size = reader.size()
                  if size.isValid() and size.width() * size.height() <= 40_000_000:
                      reader.setScaledSize(size.scaled(270, 170, QtCore.Qt.KeepAspectRatio))
                      picture = reader.read()
                      if not picture.isNull():
                          bubble['preview'].setPixmap(QtGui.QPixmap.fromImage(picture))
                          bubble['preview'].show()

          def open_file(self):
              path = self.sender().property('file_path')
              if path:
                  QtGui.QDesktopServices.openUrl(QtCore.QUrl.fromLocalFile(path))

          def show_full_text(self):
              message = self.sender().property('message_text')
              if message is None:
                  return
              dialog = QtWidgets.QDialog(self)
              dialog.setWindowTitle('Received message')
              dialog.resize(650, 480)
              layout = QtWidgets.QVBoxLayout(dialog)
              editor = QtWidgets.QPlainTextEdit()
              editor.setReadOnly(True)
              editor.setPlainText(message)
              layout.addWidget(editor)
              close = QtWidgets.QPushButton('Close')
              close.clicked.connect(dialog.accept)
              layout.addWidget(close)
              dialog.exec_()

          def cancel_send(self):
              try:
                  self.block.commands.put_nowait(('cancel',))
              except queue.Full:
                  self.hint.setText('Please try cancelling again in a moment.')

          def set_busy(self, busy):
              self.send_button.setEnabled(not busy)
              self.attach.setEnabled(not busy)
              self.hint.setText('Sending… You can type your next message.' if busy else
                                'Enter to send · Shift+Enter for a new line')

          def poll(self):
              bar = self.scroll.verticalScrollBar()
              following = bar.maximum() - bar.value() < 40
              changed = False
              for _ in range(300):
                  try:
                      event = self.block.events.get_nowait()
                  except queue.Empty:
                      break
                  self.display_event(event)
                  changed = True
              if changed and following:
                  QtCore.QTimer.singleShot(0, self.scroll_bottom)

          def display_event(self, e):
              direction, state = e['direction'], e['state']
              if direction == 'preparing':
                  if self.tx_bubble:
                      self.tx_bubble['status'].setText(state)
                  return
              if direction == 'notice':
                  if self.tx_bubble:
                      b = self.tx_bubble
                      b['status'].setText(state)
                      b['state'] = state
                      b['bar'].hide()
                      b['cancel'].hide()
                      self.tx_bubble = None
                  self.set_busy(False)
                  self.hint.setText(state)
                  return
              outgoing = direction == 'tx'
              bubble = self.tx_bubble if outgoing else self.rx_bubble
              if bubble is None:
                  caption = 'Receiving message…' if e['kind'] == 'text' else e['name']
                  bubble = self.add_bubble(outgoing, e['kind'], caption)
                  if outgoing:
                      self.tx_bubble = bubble
                  else:
                      self.rx_bubble = bubble
              complete = state.startswith('Complete')
              active = state.startswith(('Sending', 'Receiving', 'Waiting', 'Retry'))
              percent = 100.0 if complete else min(99.9, 100.0 * e['done'] / max(1, e['total']))
              bubble.update(state=state, done=e['done'], total=e['total'])
              bubble['bar'].setValue(round(percent * 10))
              if complete:
                  if not outgoing:
                      if e['kind'] == 'text':
                          message = e['text']
                          bubble['text'] = message
                          bubble['label'].setText(message[:4096] +
                              ('\n[Select View full message below]' if len(message) > 4096 else ''))
                          if len(message) > 4096:
                              bubble['open'].setText('View full message')
                              bubble['open'].setProperty('message_text', message)
                              bubble['open'].clicked.connect(self.show_full_text)
                              bubble['open'].show()
                      else:
                          self.show_file(bubble, e['path'])
                  bubble['status'].setText(bubble['time'] + ('  ·  ✓ Delivered' if outgoing else '  ·  Received'))
              elif active:
                  stage = ('Checking file…' if 'verification' in state else
                           state if state.startswith('Retry') else
                           'Sending' if outgoing else 'Receiving')
                  bubble['status'].setText('%s · %.1f%%' % (stage, percent))
              else:
                  bubble['status'].setText(state)
              if not active:
                  bubble['bar'].hide()
                  bubble['cancel'].hide()
                  if outgoing:
                      self.tx_bubble = None
                      self.set_busy(False)
                  else:
                      self.rx_bubble = None

          def scroll_bottom(self):
              bar = self.scroll.verticalScrollBar()
              bar.setValue(bar.maximum())

          def resizeEvent(self, event):
              super().resizeEvent(event)
              for message in self.messages:
                  message['card'].setMaximumWidth(max(260, int(self.width() * 0.73)))

          def open_folder(self):
              try:
                  Path(self.block.receive_dir).mkdir(parents=True, exist_ok=True)
                  QtGui.QDesktopServices.openUrl(QtCore.QUrl.fromLocalFile(self.block.receive_dir))
              except OSError as exc:
                  self.hint.setText(str(exc))

          def closeEvent(self, event):
              if self.allow_close:
                  event.accept()
              else:
                  self.showMinimized()
                  event.ignore()  # Use GRC Stop to close the flowgraph and both chats.
    my_addr: my_addr
    peer_addr: peer_addr
    receive_dir: '''./received_A1'''
    show_gui: 'False'
  states: {state: disabled}
- name: epy_transfer_protocol
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: encrypted transfer protocol and ARQ, without GUI.
      Ports: rx_in, command_in, config_in; tx_out, event_out.
      """
      import hashlib
      import io
      import json
      import os
      from pathlib import Path
      import queue
      import re
      import secrets
      import struct
      import tempfile
      import threading
      import time
      import subprocess
      from collections import OrderedDict
      from cryptography.fernet import Fernet, InvalidToken
      from gnuradio import gr
      import pmt

      _META, _DATA, _END, _ACK, _ERROR, _CANCEL = range(1, 7)
      _HEADER = struct.Struct('!4sB2s2s16sI')
      _MAGIC = b'NGS2'


      class blk(gr.basic_block):
          """All protocol, encryption, file I/O, ACKs and retries."""

          def __init__(self, my_addr='A1', peer_addr='B1',
                       shared_key='u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=',
                       receive_dir='./received_A1', max_retries=20,
                       max_file_mb=16, auto_encode_media=True,
                       image_max_edge=1600, image_quality=80,
                       audio_bitrate_kbps=64):
              gr.basic_block.__init__(self, name='Transfer Protocol', in_sig=None, out_sig=None)
              self.commands = queue.Queue(maxsize=2048)
              self.halt = threading.Event()
              self.worker = None
              self.settings = {'timeout': {}, 'size': {}, 'window': {}, 'interval': {}}
              self.config = (my_addr, peer_addr, shared_key, receive_dir,
                             self._publish, self._event, 512, 1.0,
                             max_retries, max_file_mb, 4, 0.02)
              self.core = None
              self.auto_encode_media = bool(auto_encode_media)
              self.image_max_edge = int(image_max_edge)
              self.image_quality = int(image_quality)
              self.audio_bitrate_kbps = int(audio_bitrate_kbps)
              if not 320 <= self.image_max_edge <= 8192:
                  raise ValueError('image_max_edge must be 320..8192')
              if not 40 <= self.image_quality <= 95:
                  raise ValueError('image_quality must be 40..95')
              if not 24 <= self.audio_bitrate_kbps <= 256:
                  raise ValueError('audio_bitrate_kbps must be 24..256')
              self.preparing = False
              self.prepare_id = 0
              for name, handler in (('rx_in', self._receive),
                                    ('command_in', self._command),
                                    ('config_in', self._configure)):
                  port = pmt.intern(name)
                  self.message_port_register_in(port)
                  self.set_msg_handler(port, handler)
              for name in ('tx_out', 'event_out'):
                  self.message_port_register_out(pmt.intern(name))

          @staticmethod
          def _bytes(msg):
              if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):
                  return bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              return None

          def _publish(self, raw):
              self.message_port_pub(pmt.intern('tx_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def _event(self, event):
              raw = json.dumps(event, ensure_ascii=True).encode('utf-8')
              self.message_port_pub(pmt.intern('event_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def _receive(self, msg):
              raw = self._bytes(msg)
              if raw is not None and len(raw) <= 4092:
                  try:
                      self.commands.put_nowait(('rx', raw))
                  except queue.Full:
                      pass

          def _command(self, msg):
              raw = self._bytes(msg)
              if raw is None or len(raw) > 8192:
                  return
              try:
                  command = json.loads(raw.decode('utf-8'))
                  action = command.get('cmd')
                  if action == 'send' and command.get('kind') in ('text', 'image', 'audio'):
                      item = ('send', command['kind'], command['value'])
                  elif action == 'cancel':
                      item = ('cancel',)
                  else:
                      return
                  self.commands.put_nowait(item)
              except (ValueError, UnicodeError, KeyError, AttributeError, queue.Full):
                  pass

          def _configure(self, msg):
              raw = self._bytes(msg)
              if raw is None or len(raw) > 2048:
                  return
              try:
                  config = json.loads(raw.decode('utf-8'))
                  category = config['category']
                  values = config['values']
                  if category not in self.settings or set(values) != {'text', 'image', 'audio'}:
                      raise ValueError('Unknown profile category or transfer type')
                  checked = {}
                  for kind, value in values.items():
                      if category in ('size', 'window'):
                          if type(value) is not int:
                              raise ValueError(category + ' must be an integer')
                          if not (128 <= value <= 1024 if category == 'size' else 1 <= value <= 32):
                              raise ValueError(category + ' outside supported range')
                      else:
                          if type(value) not in (int, float):
                              raise ValueError(category + ' must be numeric')
                          if not (0.05 <= value <= 30 if category == 'timeout' else 0 <= value <= 5):
                              raise ValueError(category + ' outside supported range')
                      checked[kind] = value
                  self.settings[category] = checked
              except (ValueError, TypeError, KeyError, AttributeError) as exc:
                  self._event(dict(direction='notice', state='Invalid profile: ' + str(exc)))

          def start(self):
              self.halt.clear()
              self.worker = threading.Thread(target=self._run, name='file-transfer', daemon=True)
              self.worker.start()
              return True

          def _run(self):
              try:
                  while not self.halt.is_set():
                      if self.core is None and all(self.settings.values()):
                          profiles = {kind: (
                              self.settings['size'][kind], self.settings['timeout'][kind],
                              self.settings['interval'][kind], self.settings['window'][kind])
                              for kind in ('text', 'image', 'audio')}
                          self.core = _TransferCore(*self.config, profiles=profiles)
                          self._event(dict(direction='notice', state='Transfer profiles ready'))
                      try:
                          cmd = self.commands.get(timeout=0.01)
                      except queue.Empty:
                          if self.core is not None:
                              self.core.tick()
                          continue
                      if self.core is None:
                          if cmd[0] == 'send':
                              self._event(dict(direction='notice', state='Waiting for all four profile blocks'))
                          continue
                      if cmd[0] == 'rx':
                          self.core.receive(cmd[1])
                      elif cmd[0] == 'send':
                          try:
                              if self.preparing or self.core.tx is not None:
                                  raise ValueError('A transfer is already active')
                              if self.auto_encode_media and cmd[1] in ('image', 'audio'):
                                  self.preparing = True
                                  self.prepare_id += 1
                                  job = self.prepare_id
                                  self._event(dict(direction='preparing', state='Encoding file',
                                                   kind=cmd[1]))
                                  threading.Thread(target=self._prepare_media,
                                      args=(job, cmd[1], cmd[2]), daemon=True).start()
                              else:
                                  self.core.send(cmd[1], cmd[2])
                          except Exception as exc:
                              self._event(dict(direction='notice', state=str(exc)))
                      elif cmd[0] == 'prepared':
                          if self.preparing and cmd[1] == self.prepare_id:
                              self.preparing = False
                              try:
                                  self.core.send_prepared(cmd[2], cmd[3], cmd[4])
                              except Exception as exc:
                                  self._event(dict(direction='notice', state=str(exc)))
                      elif cmd[0] == 'prepare_error':
                          if self.preparing and cmd[1] == self.prepare_id:
                              self.preparing = False
                              self._event(dict(direction='notice', state=cmd[2]))
                      elif cmd[0] == 'cancel':
                          if self.preparing:
                              self.prepare_id += 1
                              self.preparing = False
                              self._event(dict(direction='tx', state='Cancelled', kind='',
                                               name='', total=0, done=0))
                          else:
                              self.core.cancel()
                      self.core.tick()
              except Exception as exc:
                  self._event(dict(direction='notice', state='Worker stopped: ' + str(exc)))
                  print('[Transfer Protocol] Worker stopped:', exc, flush=True)
              finally:
                  if self.core is not None:
                      self.core.close()

          def stop(self):
              self.halt.set()
              self.prepare_id += 1
              if self.worker is not None:
                  self.worker.join(timeout=3)
              return True

          def _prepare_media(self, job, kind, value):
              try:
                  path = Path(value)
                  if not path.is_file() or path.stat().st_size > self.core.limit:
                      raise ValueError('Choose a file within the configured size limit')
                  original = path.read_bytes()
                  data, name = original, path.name
                  try:
                      if kind == 'image':
                          data, name = self._encode_image(path, original)
                      else:
                          data, name = self._encode_audio(path, original)
                  except (ImportError, OSError, subprocess.SubprocessError, ValueError) as exc:
                      print('[Media] Encoder unavailable; sending original:', exc, flush=True)
                  if len(data) > self.core.limit:
                      raise ValueError('Encoded file exceeds the configured size limit')
                  if self.halt.is_set():
                      return
                  print('[Media] %s: %d -> %d bytes (%s)' %
                        (kind, len(original), len(data), name), flush=True)
                  self.commands.put(('prepared', job, kind, data, name), timeout=5)
              except Exception as exc:
                  try:
                      self.commands.put(('prepare_error', job, str(exc)), timeout=5)
                  except queue.Full:
                      pass

          def _encode_image(self, path, original):
              from PIL import Image, ImageOps
              with Image.open(path) as image:
                  if getattr(image, 'n_frames', 1) != 1 or image.width * image.height > 40_000_000:
                      return original, path.name
                  image = ImageOps.exif_transpose(image)
                  ext = path.suffix.lower()
                  if ext == '.png' or 'A' in image.getbands():
                      # Keep graphics, text and transparency lossless.
                      out = io.BytesIO()
                      image.save(out, format='PNG', optimize=True)
                      candidate, name = out.getvalue(), path.stem + '.png'
                  else:
                      image = image.convert('RGB')
                      image.thumbnail((self.image_max_edge, self.image_max_edge), Image.Resampling.LANCZOS)
                      out = io.BytesIO()
                      image.save(out, format='JPEG', quality=self.image_quality,
                                 optimize=True, progressive=True)
                      candidate, name = out.getvalue(), path.stem + '.jpg'
                  return (candidate, name) if len(candidate) < len(original) else (original, path.name)

          def _encode_audio(self, path, original):
              if path.suffix.lower() in ('.ogg', '.opus'):
                  return original, path.name
              result = subprocess.run([
                  'ffmpeg', '-nostdin', '-v', 'error', '-i', str(path), '-vn',
                  '-c:a', 'libopus', '-b:a', '%dk' % self.audio_bitrate_kbps,
                  '-vbr', 'on', '-compression_level', '10', '-ar', '48000',
                  '-f', 'ogg', 'pipe:1'], capture_output=True, timeout=300, check=True)
              candidate = result.stdout
              return (candidate, path.stem + '.ogg') if 0 < len(candidate) < len(original) else (original, path.name)


      class _TransferCore:
          """Selective Repeat, independently in each direction (one file per direction).

          META (0) is acknowledged before DATA (1..N). DATA uses a bounded sliding
          window and individual ACKs/timers. END (N+1) is sent after all DATA ACKs,
          and acknowledged only after SHA-256 verification and saving the file.
          32-bit sequence numbers never wrap within a transfer. A random 128-bit
          transfer ID separates transfers. All methods run on one worker thread.
          """
          def __init__(self, my_addr, peer_addr, shared_key, receive_dir, emit, event,
                       chunk_size=512, ack_timeout=1.0, max_retries=8,
                       max_file_mb=16, window_size=4, packet_interval=0.02,
                       clock=time.monotonic, profiles=None):
              for addr in (my_addr, peer_addr):
                  if not isinstance(addr, str) or len(addr.encode('ascii')) != 2:
                      raise ValueError('Addresses must be exactly two ASCII characters')
              if my_addr == peer_addr:
                  raise ValueError('Local and peer addresses must differ')
              if not 128 <= int(chunk_size) <= 1024:
                  raise ValueError('chunk_size must be 128..1024 bytes')
              if not 0.05 <= float(ack_timeout) <= 30 or not 0 <= int(max_retries) <= 20:
                  raise ValueError('ack_timeout: 0.05..30 seconds; max_retries: 0..20')
              if not 1 <= int(max_file_mb) <= 256:
                  raise ValueError('max_file_mb must be 1..256')
              if not 1 <= int(window_size) <= 32:
                  raise ValueError('window_size must be 1..32 packets')
              if not 0 <= float(packet_interval) <= 5:
                  raise ValueError('packet_interval must be 0..5 seconds')
              key = shared_key.encode('ascii') if isinstance(shared_key, str) else shared_key
              self.cipher = Fernet(key)
              self.me, self.peer = my_addr.encode('ascii'), peer_addr.encode('ascii')
              self.directory = Path(receive_dir).expanduser().resolve()
              self.emit, self.event, self.clock = emit, event, clock
              self.chunk, self.window = int(chunk_size), int(window_size)
              self.timeout, self.retries = float(ack_timeout), int(max_retries)
              self.interval = float(packet_interval)
              self.profiles = {}
              for kind in ('text', 'image', 'audio'):
                  values = (profiles or {}).get(kind, (chunk_size, ack_timeout, packet_interval, window_size))
                  chunk, timeout, interval, kind_window = values
                  if isinstance(chunk, bool) or int(chunk) != chunk or not 128 <= int(chunk) <= 1024:
                      raise ValueError(kind + '_chunk_size must be an integer, 128..1024 bytes')
                  if not 0.05 <= float(timeout) <= 30:
                      raise ValueError(kind + '_ack_timeout must be 0.05..30 seconds')
                  if not 0 <= float(interval) <= 5:
                      raise ValueError(kind + '_packet_interval must be 0..5 seconds')
                  if type(kind_window) is not int or not 1 <= kind_window <= 32:
                      raise ValueError(kind + '_window_size must be 1..32 packets')
                  self.profiles[kind] = dict(chunk=int(chunk), timeout=float(timeout),
                                             interval=float(interval), window=kind_window)
              self.limit = int(max_file_mb) * 1024 * 1024
              # Allow a complete retry round even when 32 packets are heavily paced.
              self.idle_timeout = max(120, 4 * (self.retries + 1) *
                                      (self.timeout + 32 * self.interval))
              self.idle_timeout = max(self.idle_timeout, *(self._idle_budget(
                  p['timeout'], p['interval'], self.retries, p['window']) for p in self.profiles.values()))
              # Retain completion receipts for the longest permitted remote retry budget.
              self.receipt_ttl = max(1800, 2 * self._idle_budget(30, 5, 20))
              self.tx = self.rx = None
              self.next_emit = 0.0
              self.receipts = OrderedDict()

          @staticmethod
          def _idle_budget(timeout, interval, retries, window=32):
              return max(120, 4 * (retries + 1) * (timeout + window * interval))

          def _event(self, direction, state, transfer=None, **extra):
              t = transfer or {}
              self.event(dict(direction=direction, state=state, name=t.get('name', ''),
                              kind=t.get('kind', ''), total=t.get('size', 0),
                              done=t.get('done', 0), started=t.get('started', self.clock()),
                              **extra))

          def _wire(self, typ, tid, seq, body=b''):
              plaintext = _HEADER.pack(_MAGIC, typ, self.me, self.peer, tid, seq) + body
              frame = self.me + self.peer + self.cipher.encrypt(plaintext)
              if len(frame) > 4092:
                  raise ValueError('Encrypted frame exceeds 4092-byte PDU budget')
              return frame

          def _reply(self, typ, tid, seq, body=b''):
              # ACK/error/control replies bypass DATA pacing. Already queued downstream
              # PDUs cannot be overtaken; size the timeout for the complete RF pipeline.
              self.emit(self._wire(typ, tid, seq, body))

          @staticmethod
          def _safe_name(name):
              name = str(name).replace('\\', '/').split('/')[-1]
              name = re.sub(r'[^\w. -]', '_', name, flags=re.UNICODE).strip('. ')[:100]
              return name or 'received.bin'

          def send(self, kind, value):
              if self.tx is not None:
                  raise ValueError('A transfer is already active')
              if kind == 'text':
                  data, name = value.encode('utf-8'), 'message.txt'
                  if not data or len(data) > 65536:
                      raise ValueError('Type a message of 1..65536 UTF-8 bytes')
              elif kind in ('image', 'audio'):
                  path = Path(value)
                  if not path.is_file() or path.stat().st_size > self.limit:
                      raise ValueError('Choose a file within the configured size limit')
                  with path.open('rb') as f:
                      data = f.read(self.limit + 1)
                  name = path.name
              else:
                  raise ValueError('Unsupported transfer type')
              self.send_prepared(kind, data, name)

          def send_prepared(self, kind, data, name):
              if self.tx is not None:
                  raise ValueError('A transfer is already active')
              if kind not in ('text', 'image', 'audio') or not isinstance(data, bytes):
                  raise ValueError('Invalid prepared transfer')
              if kind == 'text' and (not data or len(data) > 65536):
                  raise ValueError('Type a message of 1..65536 UTF-8 bytes')
              if len(data) > self.limit:
                  raise ValueError('File exceeds the configured size limit')
              profile = self.profiles[kind]
              chunk = profile['chunk']
              self.tx = dict(tid=secrets.token_bytes(16), data=data, kind=kind,
                             chunk=chunk, timeout=profile['timeout'], interval=profile['interval'],
                             window=profile['window'],
                             name=self._safe_name(name), size=len(data), done=0,
                             started=self.clock(), n=(len(data) + chunk - 1) // chunk,
                             digest=hashlib.sha256(data).hexdigest(), phase='meta',
                             base=1, next=1, acked=set(), pending={})
              t = self.tx
              meta = dict(kind=t['kind'], name=t['name'], size=t['size'], chunk=t['chunk'],
                          ack_timeout=t['timeout'], packet_interval=t['interval'], max_retries=self.retries,
                          window=t['window'], sha256=t['digest'])
              self._queue_packet(_META, 0, json.dumps(meta, ensure_ascii=True,
                                 separators=(',', ':')).encode())
              self._event('tx', 'Sending metadata', t)
              print('[Transfer profile] %s: payload=%d bytes, ACK timeout=%.3f s, interval=%.3f s'
                    % (kind, t['chunk'], t['timeout'], t['interval']), flush=True)
              self._pump()

          def _queue_packet(self, typ, seq, body):
              t = self.tx
              t['pending'][seq] = dict(wire=self._wire(typ, t['tid'], seq, body),
                                       sent=None, retry=0)

          def _fill_window(self):
              t = self.tx
              if t['phase'] != 'data':
                  return
              # The window is anchored at the oldest unacknowledged sequence number,
              # not merely at the number of pending packets. This bounds RX buffering.
              while t['next'] <= t['n'] and t['next'] < t['base'] + t['window']:
                  seq = t['next']
                  self._queue_packet(_DATA, seq,
                                     t['data'][(seq - 1) * t['chunk']:seq * t['chunk']])
                  t['next'] += 1
              if t['base'] > t['n']:
                  t['phase'] = 'end'
                  self._queue_packet(_END, t['n'] + 1, bytes.fromhex(t['digest']))
                  self._event('tx', 'Waiting for file verification', t)

          def _acknowledge(self, tid, seq, body):
              t = self.tx
              if body or t is None or t['tid'] != tid:
                  return
              packet = t['pending'].get(seq)
              if packet is None or packet['sent'] is None:
                  return  # Duplicate/stale ACK, or a sequence not yet transmitted.
              del t['pending'][seq]
              if t['phase'] == 'meta':
                  t['phase'] = 'data'
              elif t['phase'] == 'end':
                  self._event('tx', 'Complete — receiver verified', t)
                  self.tx = None
                  return
              else:
                  t['done'] += min(t['chunk'], t['size'] - (seq - 1) * t['chunk'])
                  t['acked'].add(seq)
                  while t['base'] in t['acked']:
                      t['acked'].remove(t['base'])
                      t['base'] += 1
                  self._event('tx', 'Sending', t)
              self._fill_window()
              self._pump()

          def _pump(self):
              """Emit at most one DATA/META/END PDU per call, with retry priority."""
              t, now = self.tx, self.clock()
              if t is None or now < self.next_emit:
                  return
              expired = [(p['sent'], seq) for seq, p in t['pending'].items()
                         if p['sent'] is not None and now - p['sent'] >= t['timeout']]
              if expired:
                  _, seq = min(expired)
                  p = t['pending'][seq]
                  if p['retry'] >= self.retries:
                      self._abort_tx('Unconfirmed — ACK timeout for packet %d' % seq)
                      return
                  p['retry'] += 1
                  self._event('tx', 'Retry packet %d (%d/%d)' %
                              (seq, p['retry'], self.retries), t)
              else:
                  seq = next((s for s, p in t['pending'].items() if p['sent'] is None), None)
                  if seq is None:
                      return
                  p = t['pending'][seq]
              p['sent'] = now  # Timestamp PDU submission, not an RF hardware timestamp.
              self.next_emit = now + t['interval']
              self.emit(p['wire'])

          def receive(self, frame):
              # The upstream CRC Check must drop failures and remove the CRC bytes.
              if len(frame) < 5 or len(frame) > 4092 or frame[:4] != self.peer + self.me:
                  return
              try:
                  raw = self.cipher.decrypt(frame[4:])
                  if len(raw) < _HEADER.size:
                      return
                  magic, typ, src, dst, tid, seq = _HEADER.unpack(raw[:_HEADER.size])
                  if magic != _MAGIC or src != self.peer or dst != self.me:
                      return
                  body = raw[_HEADER.size:]
              except (InvalidToken, ValueError, struct.error):
                  return
              if typ == _ACK:
                  self._acknowledge(tid, seq, body)
              elif typ == _ERROR:
                  if self.tx and tid == self.tx['tid'] and seq in self.tx['pending']:
                      self._abort_tx('Failed: ' + body.decode('utf-8', 'replace')[:180])
              elif typ == _CANCEL:
                  if body:
                      return
                  if self.rx and self.rx['tid'] == tid:
                      self._drop_rx('Cancelled by sender')
                  elif tid not in self.receipts:
                      # A reordered CANCEL can arrive before its META.
                      self._remember(tid, error='Cancelled by sender')
              elif typ in (_META, _DATA, _END):
                  try:
                      self._receive_data(typ, tid, seq, body)
                  except (ValueError, OSError, UnicodeError, KeyError, TypeError) as exc:
                      reason = str(exc)[:180]
                      if self.rx and self.rx['tid'] == tid:
                          self._drop_rx('Failed: ' + reason)
                      elif tid not in self.receipts:
                          self._remember(tid, error=reason)
                      self._reply(_ERROR, tid, seq, reason.encode('utf-8')[:180])

          def _remember(self, tid, **fields):
              self.receipts[tid] = dict(at=self.clock(), **fields)
              self.receipts.move_to_end(tid)
              while len(self.receipts) > 256:
                  self.receipts.popitem(last=False)

          def _receive_data(self, typ, tid, seq, body):
              if tid in self.receipts:
                  c = self.receipts[tid]
                  if 'error' in c:
                      self._reply(_ERROR, tid, seq, c['error'].encode('utf-8')[:180])
                  elif typ == _END and seq == c['seq'] and body == c['digest']:
                      self._reply(_ACK, tid, seq)  # Lost final ACK: never save twice.
                  return
              if typ == _META:
                  if seq != 0:
                      raise ValueError('Invalid metadata sequence')
                  if self.rx:
                      if self.rx['tid'] == tid and self.rx['meta'] == body:
                          self.rx['last'] = self.clock()
                          self._reply(_ACK, tid, seq)
                          return
                      raise ValueError('Receiver busy; retry after its current transfer')
                  meta = json.loads(body.decode('utf-8'))
                  if not isinstance(meta, dict):
                      raise ValueError('Invalid metadata')
                  size, chunk, window = meta.get('size'), meta.get('chunk'), meta.get('window')
                  digest, kind = meta.get('sha256'), meta.get('kind')
                  if type(size) is not int or not 0 <= size <= self.limit:
                      raise ValueError('Unsupported file size')
                  if type(chunk) is not int or not 128 <= chunk <= 1024:
                      raise ValueError('Invalid chunk size')
                  if type(window) is not int or not 1 <= window <= 32:
                      raise ValueError('Invalid window size')
                  if kind not in ('text', 'image', 'audio') or (kind == 'text' and size > 65536):
                      raise ValueError('Unsupported content type or text size')
                  if not isinstance(digest, str) or not re.fullmatch('[0-9a-f]{64}', digest):
                      raise ValueError('Invalid SHA-256')
                  if not isinstance(meta.get('name'), str) or len(meta['name']) > 200:
                      raise ValueError('Invalid filename')
                  # Optional fields allow older NGS2 senders to keep working.
                  timeout = meta.get('ack_timeout', self.timeout)
                  interval = meta.get('packet_interval', self.interval)
                  retries = meta.get('max_retries', self.retries)
                  if type(timeout) not in (int, float) or not 0.05 <= timeout <= 30:
                      raise ValueError('Invalid ACK timeout')
                  if type(interval) not in (int, float) or not 0 <= interval <= 5:
                      raise ValueError('Invalid packet interval')
                  if type(retries) is not int or not 0 <= retries <= 20:
                      raise ValueError('Invalid retry limit')
                  idle_timeout = max(self.idle_timeout, self._idle_budget(timeout, interval, retries))
                  if kind == 'text':
                      f, temp = io.BytesIO(), None
                  else:
                      self.directory.mkdir(parents=True, exist_ok=True)
                      f = tempfile.NamedTemporaryFile(mode='w+b', prefix='.incoming_',
                                                      suffix='.part', dir=self.directory, delete=False)
                      temp = Path(f.name)
                  self.rx = dict(tid=tid, meta=body, kind=kind, name=self._safe_name(meta['name']),
                                 size=size, chunk=chunk, window=window, digest=digest, idle_timeout=idle_timeout,
                                 n=(size + chunk - 1) // chunk, next=1, done=0, buffer={},
                                 hash=hashlib.sha256(), file=f, temp=temp,
                                 started=self.clock(), last=self.clock())
                  self._event('rx', 'Receiving', self.rx)
                  self._reply(_ACK, tid, seq)
                  return
              r = self.rx
              if r is None or r['tid'] != tid:
                  raise ValueError('No matching transfer; send again from the beginning')
              r['last'] = self.clock()
              if typ == _DATA:
                  if not 1 <= seq <= r['n']:
                      raise ValueError('Invalid data sequence')
                  expected = min(r['chunk'], r['size'] - (seq - 1) * r['chunk'])
                  if len(body) != expected:
                      raise ValueError('Invalid chunk length')
                  if seq < r['next']:
                      self._reply(_ACK, tid, seq)  # Re-ACK without writing twice.
                      return
                  if seq >= r['next'] + r['window']:
                      return  # Out of receive window: do not ACK unretained data.
                  if seq not in r['buffer']:
                      r['buffer'][seq] = body
                      r['done'] += len(body)  # Unique accepted bytes, including buffered ones.
                  elif r['buffer'][seq] != body:
                      raise ValueError('Conflicting duplicate packet')
                  while r['next'] in r['buffer']:
                      contiguous = r['buffer'].pop(r['next'])
                      r['file'].write(contiguous)
                      r['hash'].update(contiguous)
                      r['next'] += 1
                  self._event('rx', 'Receiving', r)
                  self._reply(_ACK, tid, seq)
              elif typ == _END:
                  if seq != r['n'] + 1 or r['next'] != seq or r['done'] != r['size'] or r['buffer']:
                      raise ValueError('Incomplete file')
                  if body != bytes.fromhex(r['digest']) or r['hash'].hexdigest() != r['digest']:
                      raise ValueError('Whole-file SHA-256 mismatch')
                  if r['kind'] == 'text':
                      message = r['file'].getvalue().decode('utf-8')
                      r['file'].close()
                      result = dict(text=message)
                      state = 'Complete — displayed and verified'
                  else:
                      r['file'].flush()
                      os.fsync(r['file'].fileno())
                      r['file'].close()
                      final = self.directory / (tid.hex() + '_' + r['name'])
                      os.replace(r['temp'], final)
                      result = dict(path=str(final))
                      state = 'Complete — saved and verified'
                  self._remember(tid, seq=seq, digest=body)
                  self.rx = None
                  self._reply(_ACK, tid, seq)
                  self._event('rx', state, r, **result)

          def tick(self):
              self._pump()
              now = self.clock()
              if self.rx and now - self.rx['last'] >= self.rx['idle_timeout']:
                  self._drop_rx('Timed out — partial file removed')
              for tid, entry in list(self.receipts.items()):
                  if now - entry['at'] > self.receipt_ttl:
                      del self.receipts[tid]

          def _abort_tx(self, reason):
              if self.tx:
                  t, self.tx = self.tx, None
                  self._reply(_CANCEL, t['tid'], 0)
                  self._event('tx', reason, t)

          def cancel(self):
              self._abort_tx('Cancelled — peer may have received some data')

          def _drop_rx(self, reason):
              r, self.rx = self.rx, None
              if r:
                  self._remember(r['tid'], error=reason)
                  try:
                      r['file'].close()
                  except OSError:
                      pass
                  if r['temp'] is not None:
                      try:
                          r['temp'].unlink(missing_ok=True)
                      except OSError as exc:
                          reason += '; partial-file cleanup failed: ' + str(exc)
                  self._event('rx', reason, r)

          def close(self):
              self.tx = None
              self._drop_rx('Stopped — partial file removed')
    audio_bitrate_kbps: '64'
    auto_encode_media: 'True'
    comment: Encrypted transfer and ACK protocol
    image_max_edge: '1600'
    image_quality: '80'
    max_file_mb: '16'
    max_retries: '20'
    my_addr: my_addr
    peer_addr: peer_addr
    receive_dir: '''./received_A1'''
    shared_key: shared_key
  states: {state: disabled}
- name: epy_window_profiles
  id: epy_block
  parameters:
    _source_code: |
      """Embedded Python Block: window profiles for text, image and audio.
      Connect config_out to Transfer Protocol.config_in.
      """
      import json
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, text=4, image=4, audio=4):
              gr.basic_block.__init__(self, name='Window Profiles',
                                      in_sig=None, out_sig=None)
              self.values = {'text': int(text), 'image': int(image),
                             'audio': int(audio)}
              for value in self.values.values():
                  if not (1, 32)[0] <= value <= (1, 32)[1]:
                      raise ValueError('window must be within (1, 32)')
              self.message_port_register_out(pmt.intern('config_out'))

          def start(self):
              raw = json.dumps({'category': 'window', 'values': self.values}).encode('utf-8')
              self.message_port_pub(pmt.intern('config_out'),
                  pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))
              return True
    audio: '32'
    image: '32'
    text: '4'
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Contellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2460000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.42e9
    fftsize: '1024'
    name: '"Before AGC"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Before AGC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', analog_agc_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_rs_encoder, pdu_in]
- [digital_crc_check_0_0, fail, blocks_message_debug_0, print]
- [digital_crc_check_0_0, fail, epy_block_0, crc_fail]
- [digital_crc_check_0_0, ok, epy_block_0, crc_ok]
- [digital_crc_check_0_0, ok, epy_block_1, rx_in]
- [digital_crc_check_0_0, ok, epy_transfer_protocol, rx_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', qtgui_const_sink_x_2, '0']
- [epy_block_1, event_out, epy_block_2, event_in]
- [epy_block_1, tx_out, digital_crc_append_0, in]
- [epy_block_2, command_out, epy_block_1, command_in]
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_interval_profiles, config_out, epy_transfer_protocol, config_in]
- [epy_rs_decoder, fail, epy_block_0, rs_fail]
- [epy_rs_decoder, pdu_out, digital_crc_check_0_0, in]
- [epy_rs_decoder, pdu_out, epy_block_0, rs_ok]
- [epy_rs_encoder, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_rs_encoder, pdu_out, epy_block_0, tx]
- [epy_size_profiles, config_out, epy_transfer_protocol, config_in]
- [epy_timeout_profiles, config_out, epy_transfer_protocol, config_in]
- [epy_transfer_chat_gui, command_out, epy_transfer_protocol, command_in]
- [epy_transfer_protocol, event_out, epy_transfer_chat_gui, event_in]
- [epy_transfer_protocol, tx_out, digital_crc_append_0, in]
- [epy_window_profiles, config_out, epy_transfer_protocol, config_in]
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_rs_decoder, pdu_in]
- [epy_block_2, chat_out, epy_transfer_protocol, command_in]
- [epy_transfer_protocol, event_out, epy_block_2, chat_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
