options:
  parameters:
    author: Pixel_Pulse
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Version_1
    output_language: python
    title: CDP
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: cma_alg_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: damp_fac_0
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_0
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_offset_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_1
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise_volt_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: phase_bw_0
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_0
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sender_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0,0.7,0.4,0.15]'
  states: {}
- name: taps_0
  id: variable
  parameters:
    value: '[1.0,0.7,0.4,0.15]'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1.000'
  states: {}
- name: time_offset_0
  id: variable
  parameters:
    value: '1.000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_3
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_3_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(b"Hello Node B"), list(b"Hello Node B")))
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    comment: |-
      Simulated channel
      Block tag propogation 
      set to off
      because realistically
      over air transmission 
      doesnt preserve metadata
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: channels_channel_model_0_1_0
  id: channels_channel_model
  parameters:
    comment: |-
      Simulated channel
      Block tag propogation 
      set to off
      because realistically
      over air transmission 
      doesnt preserve metadata
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '15'
    sps: '1'
    training_start_tag: '""'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '15'
    sps: '1'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """Prints PDU payloads as readable ASCII text"""

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Plain Text Printer',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  data_pmt = pmt.cdr(msg)
                  try:
                      # Extract the raw bytes from the packet
                      raw_bytes = bytes(pmt.u8vector_elements(data_pmt))
                      
                      # Strip off the last 4 bytes (which is the CRC32 checksum math)
                      text_bytes = raw_bytes[:-4]
                      
                      # Decode the remaining bytes into readable English text
                      text = text_bytes.decode('utf-8', errors='ignore')
                      
                      # Print a clean, formatted message to the console
                      print(f"\nSUCCESS! RECEIVED MESSAGE: {text}\n")
                  except Exception as e:
                      print("Could not decode text:", e)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """Prints PDU payloads as readable ASCII text"""

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Plain Text Printer',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  data_pmt = pmt.cdr(msg)
                  try:
                      # Extract the raw bytes from the packet
                      raw_bytes = bytes(pmt.u8vector_elements(data_pmt))
                      
                      # Strip off the last 4 bytes (which is the CRC32 checksum math)
                      text_bytes = raw_bytes[:-4]
                      
                      # Decode the remaining bytes into readable English text
                      text = text_bytes.decode('utf-8', errors='ignore')
                      
                      # Print a clean, formatted message to the console
                      print(f"\nSUCCESS! RECEIVED MESSAGE: {text}\n")
                  except Exception as e:
                      print("Could not decode text:", e)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import time
      import threading
      import sys

      class blk(gr.basic_block):
          def __init__(self, msg_file="/tmp/sdr_message.bin"):
              gr.basic_block.__init__(
                  self,
                  name='GUI Message Source',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('out'))
              self.msg_file = msg_file
              self.running = True
              print(f"[GUI Source] Initialized and watching {self.msg_file}", flush=True)
              
              # Start a background thread to poll for GUI text files
              self.thread = threading.Thread(target=self.poll_loop)
              self.thread.daemon = True
              self.thread.start()

          def poll_loop(self):
              while self.running:
                  if os.path.exists(self.msg_file):
                      try:
                          print("[GUI Source] File detected! Reading payload...", flush=True)
                          with open(self.msg_file, "rb") as f:
                              payload_bytes = f.read()
                          os.remove(self.msg_file)
                          
                          if len(payload_bytes) > 0:
                              print(f"[GUI Source] Publishing {len(payload_bytes)} bytes to flowgraph.", flush=True)
                              vector = pmt.init_u8vector(len(payload_bytes), list(payload_bytes))
                              msg = pmt.cons(pmt.PMT_NIL, vector)
                              self.message_port_pub(pmt.intern('out'), msg)
                      except Exception as e:
                          print(f"[GUI Source Error] {e}", file=sys.stderr, flush=True)
                  time.sleep(0.05)

          def stop(self):
              self.running = False
              return True
    msg_file: '"/tmp/nodeA_tx.bin"'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import time
      import threading
      import sys

      class blk(gr.basic_block):
          def __init__(self, msg_file="/tmp/sdr_message.bin"):
              gr.basic_block.__init__(
                  self,
                  name='GUI Message Source',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('out'))
              self.msg_file = msg_file
              self.running = True
              print(f"[GUI Source] Initialized and watching {self.msg_file}", flush=True)
              
              # Start a background thread to poll for GUI text files
              self.thread = threading.Thread(target=self.poll_loop)
              self.thread.daemon = True
              self.thread.start()

          def poll_loop(self):
              while self.running:
                  if os.path.exists(self.msg_file):
                      try:
                          print("[GUI Source] File detected! Reading payload...", flush=True)
                          with open(self.msg_file, "rb") as f:
                              payload_bytes = f.read()
                          os.remove(self.msg_file)
                          
                          if len(payload_bytes) > 0:
                              print(f"[GUI Source] Publishing {len(payload_bytes)} bytes to flowgraph.", flush=True)
                              vector = pmt.init_u8vector(len(payload_bytes), list(payload_bytes))
                              msg = pmt.cons(pmt.PMT_NIL, vector)
                              self.message_port_pub(pmt.intern('out'), msg)
                      except Exception as e:
                          print(f"[GUI Source Error] {e}", file=sys.stderr, flush=True)
                  time.sleep(0.05)

          def stop(self):
              self.running = False
              return True
    msg_file: '"/tmp/nodeB_tx.bin"'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class blk(gr.basic_block):
          def __init__(self, out_file="/tmp/received_message.bin"):
              gr.basic_block.__init__(
                  self,
                  name='GUI Message Sink',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.out_file = out_file

          def handle_msg(self, msg):
              try:
                  if pmt.is_pdu(msg):
                      # Unpack the PDU payload
                      data = pmt.cdr(msg)
                      payload_bytes = bytes(pmt.u8vector_elements(data))
                      
                      # Strip the 4-byte CRC checksum from the end of the packet
                      if len(payload_bytes) > 4:
                          payload_bytes = payload_bytes[:-4]
                      
                      # Drop the decoded data into the /tmp/ folder for the Receiver App
                      with open(self.out_file, "wb") as f:
                          f.write(payload_bytes)
                      print(f"[GUI Sink] Exported {len(payload_bytes)} bytes to {self.out_file}", flush=True)
              except Exception as e:
                  print(f"[GUI Sink Error] {e}", flush=True)
    out_file: '"/tmp/nodeB_rx.bin"'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class blk(gr.basic_block):
          def __init__(self, out_file="/tmp/received_message.bin"):
              gr.basic_block.__init__(
                  self,
                  name='GUI Message Sink',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.out_file = out_file

          def handle_msg(self, msg):
              try:
                  if pmt.is_pdu(msg):
                      # Unpack the PDU payload
                      data = pmt.cdr(msg)
                      payload_bytes = bytes(pmt.u8vector_elements(data))
                      
                      # Strip the 4-byte CRC checksum from the end of the packet
                      if len(payload_bytes) > 4:
                          payload_bytes = payload_bytes[:-4]
                      
                      # Drop the decoded data into the /tmp/ folder for the Receiver App
                      with open(self.out_file, "wb") as f:
                          f.write(payload_bytes)
                      print(f"[GUI Sink] Exported {len(payload_bytes)} bytes to {self.out_file}", flush=True)
              except Exception as e:
                  print(f"[GUI Sink Error] {e}", flush=True)
    out_file: '"/tmp/nodeA_rx.bin"'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PDU Prepend Dummy Bytes
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=64):  # Default to 64 bytes
              """
              Constructor.
              Args:
                  num_dummy_bytes: The number of random bytes to prepend.
              """
              gr.basic_block.__init__(
                  self,
                  name='PDU Prepend Dummy Bytes',
                  in_sig=None,
                  out_sig=None
              )
              
              # Save the parameter
              self.num_dummy_bytes = num_dummy_bytes

              # Register message ports for PDU handling
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set up the message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              """
              Message handler that processes incoming PDUs.
              """
              # 1. Validate that the message is a PDU (it should be a pair: meta + data)
              if not pmt.is_pair(msg):
                  return

              # 2. Extract metadata and data vector
              meta = pmt.car(msg)
              data_pmt = pmt.cdr(msg)
              
              # Convert PMT vector to a numpy array (uint8)
              # We rely on pmt.u8vector_elements to get the data out
              try:
                  input_data = pmt.u8vector_elements(data_pmt)
              except:
                  # If data is not a u8vector, ignore or print error
                  return

              # 3. Generate dummy bytes for QPSK Costas Loop Sync
              # We use random integers between 0 and 255.
              # Random data ensures White Noise properties, meaning we have an equal 
              # probability of generating 00, 01, 10, and 11 bit pairs.
              # This guarantees that the transitions hit all 4 points of the QPSK 
              # constellation (1+j, 1-j, -1+j, -1-j) to energize the loop.
              dummy_data = np.random.randint(0, 256, self.num_dummy_bytes, dtype=np.uint8)
              
              # 4. Concatenate the dummy bytes with the input data
              # input_data comes out as a tuple or list from pmt, convert to array first
              combined_data = np.concatenate((dummy_data, np.array(input_data, dtype=np.uint8)))

              # 5. Create new output PMT
              # We keep the original metadata (meta)
              out_len = len(combined_data)
              out_vector = pmt.init_u8vector(out_len, combined_data)
              out_msg = pmt.cons(meta, out_vector)

              # 6. Publish the message to the output port
              self.message_port_pub(pmt.intern('pdu_out'), out_msg)
    num_dummy_bytes: '1500'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PDU Prepend Dummy Bytes
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=64):  # Default to 64 bytes
              """
              Constructor.
              Args:
                  num_dummy_bytes: The number of random bytes to prepend.
              """
              gr.basic_block.__init__(
                  self,
                  name='PDU Prepend Dummy Bytes',
                  in_sig=None,
                  out_sig=None
              )
              
              # Save the parameter
              self.num_dummy_bytes = num_dummy_bytes

              # Register message ports for PDU handling
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set up the message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              """
              Message handler that processes incoming PDUs.
              """
              # 1. Validate that the message is a PDU (it should be a pair: meta + data)
              if not pmt.is_pair(msg):
                  return

              # 2. Extract metadata and data vector
              meta = pmt.car(msg)
              data_pmt = pmt.cdr(msg)
              
              # Convert PMT vector to a numpy array (uint8)
              # We rely on pmt.u8vector_elements to get the data out
              try:
                  input_data = pmt.u8vector_elements(data_pmt)
              except:
                  # If data is not a u8vector, ignore or print error
                  return

              # 3. Generate dummy bytes for QPSK Costas Loop Sync
              # We use random integers between 0 and 255.
              # Random data ensures White Noise properties, meaning we have an equal 
              # probability of generating 00, 01, 10, and 11 bit pairs.
              # This guarantees that the transitions hit all 4 points of the QPSK 
              # constellation (1+j, 1-j, -1+j, -1-j) to energize the loop.
              dummy_data = np.random.randint(0, 256, self.num_dummy_bytes, dtype=np.uint8)
              
              # 4. Concatenate the dummy bytes with the input data
              # input_data comes out as a tuple or list from pmt, convert to array first
              combined_data = np.concatenate((dummy_data, np.array(input_data, dtype=np.uint8)))

              # 5. Create new output PMT
              # We keep the original metadata (meta)
              out_len = len(combined_data)
              out_vector = pmt.init_u8vector(out_len, combined_data)
              out_msg = pmt.cons(meta, out_vector)

              # 6. Publish the message to the output port
              self.message_port_pub(pmt.intern('pdu_out'), out_msg)
    num_dummy_bytes: '1500'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Contellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Contellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.5e9
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.5e9
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [analog_agc_xx_0_0, '0', digital_symbol_sync_xx_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', channels_channel_model_0_1_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [channels_channel_model_0_1, '0', analog_agc_xx_0, '0']
- [channels_channel_model_0_1, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0_1, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_1, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0_1_0, '0', analog_agc_xx_0_0, '0']
- [channels_channel_model_0_1_0, '0', qtgui_const_sink_x_0_1, '0']
- [channels_channel_model_0_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [channels_channel_model_0_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0_0, ok, blocks_message_debug_3, print_pdu]
- [digital_crc_check_0_0, ok, epy_block_2, in]
- [digital_crc_check_0_0_0, ok, blocks_message_debug_3_0, print_pdu]
- [digital_crc_check_0_0_0, ok, epy_block_2_0, in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_linear_equalizer_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_1_0, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_1_0_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_1, out, digital_crc_append_0, in]
- [epy_block_1_0, out, digital_crc_append_0_0, in]
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_block_3_0, pdu_out, pdu_pdu_to_tagged_stream_2_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_2_0, '0', blocks_throttle2_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, digital_crc_check_0_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
