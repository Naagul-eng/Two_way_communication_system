options:
  parameters:
    author: naagul
    description: Text, image and audio-file GUI. Both peers must use the new protocol.
    generate_options: qt_gui
    id: node_a_gui
    output_language: python
    title: Node A — QPSK File Link
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.01'
    type: cma
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''A1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: peer_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: shared_key
  id: variable
  parameters:
    value: b'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P='
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '15'
    sps: '1'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    constellation: digital.constellation_qpsk().base()
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """Replace the code in epy_block_3 with this ENTIRE file.

      Put padding OUTSIDE the protocol header and CRC-protected payload.
      The suffix flushes finite bursts through filters and hardware buffers.
      """
      import os
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=1500, num_tail_bytes=1024):
              gr.basic_block.__init__(self, name='Burst Prefix + Tail',
                                      in_sig=None, out_sig=None)
              self.prefix, self.tail = int(num_dummy_bytes), int(num_tail_bytes)
              if self.prefix < 0 or self.tail < 0:
                  raise ValueError('Padding lengths must be nonnegative')
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  return
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              padded = os.urandom(self.prefix) + raw + os.urandom(self.tail)
              self.message_port_pub(pmt.intern('pdu_out'),
                                    pmt.cons(pmt.car(msg), pmt.init_u8vector(len(padded), list(padded))))
    comment: Random prefix for acquisition; tail flushes finite bursts
    num_dummy_bytes: '1500'
    num_tail_bytes: '1024'
  states: {}
- name: epy_transfer_gui
  id: epy_block
  parameters:
    _source_code: |
      """Complete GNU Radio 3.10 Embedded Python Block: Selective Repeat chat.

      Paste the ENTIRE plain .py file into the block editor on BOTH nodes.
      Ports: rx_in = CRC-checked byte PDU, tx_out = encrypted byte PDU for CRC Append.
      Keep QPSK, framing, and FEC outside this block. Options must use QT GUI.
      Not wire-compatible with the previous Stop-and-Wait version (NGF1).
      DATA has a sliding window; META and END are individually acknowledged handshakes.
      Default shared_key is for demonstration: retain your matching key on both nodes.
      """

      import hashlib
      import json
      import os
      from pathlib import Path
      import queue
      import re
      import secrets
      import struct
      import tempfile
      import threading
      import time
      from collections import OrderedDict
      from cryptography.fernet import Fernet, InvalidToken

      _META, _DATA, _END, _ACK, _ERROR, _CANCEL = range(1, 7)
      _HEADER = struct.Struct('!4sB2s2s16sI')
      _MAGIC = b'NGS2'


      # GNU Radio / Qt adapter. The protocol core below is independently testable.
      from gnuradio import gr
      import pmt
      from PyQt5 import QtCore, QtGui, QtWidgets


      class blk(gr.basic_block):
          """Duplex text/image/audio GUI + encrypted Selective Repeat file transfer."""
          def __init__(self, my_addr='A1', peer_addr='B1',
                       shared_key='u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=',
                       receive_dir='./received_A1', chunk_size=512, ack_timeout=1.0,
                       max_retries=8, max_file_mb=16, show_gui=True,
                       window_size=4, packet_interval=0.02):
              gr.basic_block.__init__(self, name='Selective Repeat Chat GUI',
                                      in_sig=None, out_sig=None)
              self.my_addr, self.peer_addr = my_addr, peer_addr
              self.receive_dir = str(Path(receive_dir).expanduser().resolve())
              self.max_file_mb, self.show_gui = max_file_mb, show_gui
              self.commands, self.events = queue.Queue(maxsize=2048), queue.Queue()
              self.halt = threading.Event()
              self.worker = self.bridge = None
              self._config = (my_addr, peer_addr, shared_key, receive_dir, self._publish,
                              self.events.put, chunk_size, ack_timeout, max_retries, max_file_mb,
                              window_size, packet_interval)
              self.core = _TransferCore(*self._config)  # Validate only; no window/thread/files.
              self.message_port_register_in(pmt.intern('rx_in'))
              self.message_port_register_out(pmt.intern('tx_out'))
              self.set_msg_handler(pmt.intern('rx_in'), self._receive)

          def _publish(self, raw):
              self.message_port_pub(pmt.intern('tx_out'),
                                    pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def _receive(self, msg):
              if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):
                  raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
                  if len(raw) <= 4092:
                      try:
                          self.commands.put_nowait(('rx', raw))
                      except queue.Full:
                          pass  # ARQ recovers an overloaded receiver like a dropped packet.

          def start(self):
              self.halt.clear()
              self.core = _TransferCore(*self._config)
              if self.show_gui:
                  app = QtWidgets.QApplication.instance()
                  if app is None:
                      print('[Transfer GUI] Set Options > Generate Options = QT GUI')
                      return False
                  self.bridge = _WindowBridge(self)
                  self.bridge.moveToThread(app.thread())
                  self.bridge.open_requested.emit()
              self.worker = threading.Thread(target=self._run, name='file-transfer', daemon=True)
              self.worker.start()
              return True

          def _run(self):
              try:
                  while not self.halt.is_set():
                      try:
                          cmd = self.commands.get(timeout=0.01)
                          if cmd[0] == 'rx':
                              self.core.receive(cmd[1])
                          elif cmd[0] == 'send':
                              try:
                                  self.core.send(cmd[1], cmd[2])
                              except Exception as exc:
                                  self.events.put(dict(direction='notice', state=str(exc)))
                          elif cmd[0] == 'cancel':
                              self.core.cancel()
                      except queue.Empty:
                          pass
                      self.core.tick()
              except Exception as exc:
                  self.events.put(dict(direction='notice', state='Worker stopped: ' + str(exc)))
                  print('[Transfer GUI] Worker stopped:', exc, flush=True)
              finally:
                  self.core.close()

          def stop(self):
              self.halt.set()
              if self.worker:
                  self.worker.join(timeout=3)
              if self.bridge:
                  self.bridge.close_requested.emit()
              return True


      class _TransferCore:
          """Selective Repeat, independently in each direction (one file per direction).

          META (0) is acknowledged before DATA (1..N). DATA uses a bounded sliding
          window and individual ACKs/timers. END (N+1) is sent after all DATA ACKs,
          and acknowledged only after SHA-256 verification and saving the file.
          32-bit sequence numbers never wrap within a transfer. A random 128-bit
          transfer ID separates transfers. All methods run on one worker thread.
          """
          def __init__(self, my_addr, peer_addr, shared_key, receive_dir, emit, event,
                       chunk_size=512, ack_timeout=1.0, max_retries=8,
                       max_file_mb=16, window_size=4, packet_interval=0.02,
                       clock=time.monotonic):
              for addr in (my_addr, peer_addr):
                  if not isinstance(addr, str) or len(addr.encode('ascii')) != 2:
                      raise ValueError('Addresses must be exactly two ASCII characters')
              if my_addr == peer_addr:
                  raise ValueError('Local and peer addresses must differ')
              if not 128 <= int(chunk_size) <= 1024:
                  raise ValueError('chunk_size must be 128..1024 bytes')
              if not 0.05 <= float(ack_timeout) <= 30 or not 0 <= int(max_retries) <= 20:
                  raise ValueError('ack_timeout: 0.05..30 seconds; max_retries: 0..20')
              if not 1 <= int(max_file_mb) <= 256:
                  raise ValueError('max_file_mb must be 1..256')
              if not 1 <= int(window_size) <= 32:
                  raise ValueError('window_size must be 1..32 packets')
              if not 0 <= float(packet_interval) <= 5:
                  raise ValueError('packet_interval must be 0..5 seconds')
              key = shared_key.encode('ascii') if isinstance(shared_key, str) else shared_key
              self.cipher = Fernet(key)
              self.me, self.peer = my_addr.encode('ascii'), peer_addr.encode('ascii')
              self.directory = Path(receive_dir).expanduser().resolve()
              self.emit, self.event, self.clock = emit, event, clock
              self.chunk, self.window = int(chunk_size), int(window_size)
              self.timeout, self.retries = float(ack_timeout), int(max_retries)
              self.interval = float(packet_interval)
              self.limit = int(max_file_mb) * 1024 * 1024
              # Allow a complete retry round even when 32 packets are heavily paced.
              self.idle_timeout = max(120, 4 * (self.retries + 1) *
                                      (self.timeout + 32 * self.interval))
              self.receipt_ttl = max(1800, self.idle_timeout * 2)
              self.tx = self.rx = None
              self.next_emit = 0.0
              self.receipts = OrderedDict()

          def _event(self, direction, state, transfer=None, **extra):
              t = transfer or {}
              self.event(dict(direction=direction, state=state, name=t.get('name', ''),
                              kind=t.get('kind', ''), total=t.get('size', 0),
                              done=t.get('done', 0), started=t.get('started', self.clock()),
                              **extra))

          def _wire(self, typ, tid, seq, body=b''):
              plaintext = _HEADER.pack(_MAGIC, typ, self.me, self.peer, tid, seq) + body
              frame = self.me + self.peer + self.cipher.encrypt(plaintext)
              if len(frame) > 4092:
                  raise ValueError('Encrypted frame exceeds 4092-byte PDU budget')
              return frame

          def _reply(self, typ, tid, seq, body=b''):
              # ACK/error/control replies bypass DATA pacing. Already queued downstream
              # PDUs cannot be overtaken; size the timeout for the complete RF pipeline.
              self.emit(self._wire(typ, tid, seq, body))

          @staticmethod
          def _safe_name(name):
              name = str(name).replace('\\', '/').split('/')[-1]
              name = re.sub(r'[^\w. -]', '_', name, flags=re.UNICODE).strip('. ')[:100]
              return name or 'received.bin'

          def send(self, kind, value):
              if self.tx is not None:
                  raise ValueError('A transfer is already active')
              if kind == 'text':
                  data, name = value.encode('utf-8'), 'message.txt'
                  if not data or len(data) > 65536:
                      raise ValueError('Type a message of 1..65536 UTF-8 bytes')
              elif kind in ('image', 'audio'):
                  path = Path(value)
                  if not path.is_file() or path.stat().st_size > self.limit:
                      raise ValueError('Choose a file within the configured size limit')
                  with path.open('rb') as f:
                      data = f.read(self.limit + 1)
                  name = path.name
              else:
                  raise ValueError('Unsupported transfer type')
              if len(data) > self.limit:
                  raise ValueError('File exceeds the configured size limit')
              self.tx = dict(tid=secrets.token_bytes(16), data=data, kind=kind,
                             name=self._safe_name(name), size=len(data), done=0,
                             started=self.clock(), n=(len(data) + self.chunk - 1) // self.chunk,
                             digest=hashlib.sha256(data).hexdigest(), phase='meta',
                             base=1, next=1, acked=set(), pending={})
              t = self.tx
              meta = dict(kind=t['kind'], name=t['name'], size=t['size'], chunk=self.chunk,
                          window=self.window, sha256=t['digest'])
              self._queue_packet(_META, 0, json.dumps(meta, ensure_ascii=True,
                                 separators=(',', ':')).encode())
              self._event('tx', 'Sending metadata', t)
              self._pump()

          def _queue_packet(self, typ, seq, body):
              t = self.tx
              t['pending'][seq] = dict(wire=self._wire(typ, t['tid'], seq, body),
                                       sent=None, retry=0)

          def _fill_window(self):
              t = self.tx
              if t['phase'] != 'data':
                  return
              # The window is anchored at the oldest unacknowledged sequence number,
              # not merely at the number of pending packets. This bounds RX buffering.
              while t['next'] <= t['n'] and t['next'] < t['base'] + self.window:
                  seq = t['next']
                  self._queue_packet(_DATA, seq,
                                     t['data'][(seq - 1) * self.chunk:seq * self.chunk])
                  t['next'] += 1
              if t['base'] > t['n']:
                  t['phase'] = 'end'
                  self._queue_packet(_END, t['n'] + 1, bytes.fromhex(t['digest']))
                  self._event('tx', 'Waiting for file verification', t)

          def _acknowledge(self, tid, seq, body):
              t = self.tx
              if body or t is None or t['tid'] != tid:
                  return
              packet = t['pending'].get(seq)
              if packet is None or packet['sent'] is None:
                  return  # Duplicate/stale ACK, or a sequence not yet transmitted.
              del t['pending'][seq]
              if t['phase'] == 'meta':
                  t['phase'] = 'data'
              elif t['phase'] == 'end':
                  self._event('tx', 'Complete — receiver verified', t)
                  self.tx = None
                  return
              else:
                  t['done'] += min(self.chunk, t['size'] - (seq - 1) * self.chunk)
                  t['acked'].add(seq)
                  while t['base'] in t['acked']:
                      t['acked'].remove(t['base'])
                      t['base'] += 1
                  self._event('tx', 'Sending', t)
              self._fill_window()
              self._pump()

          def _pump(self):
              """Emit at most one DATA/META/END PDU per call, with retry priority."""
              t, now = self.tx, self.clock()
              if t is None or now < self.next_emit:
                  return
              expired = [(p['sent'], seq) for seq, p in t['pending'].items()
                         if p['sent'] is not None and now - p['sent'] >= self.timeout]
              if expired:
                  _, seq = min(expired)
                  p = t['pending'][seq]
                  if p['retry'] >= self.retries:
                      self._abort_tx('Unconfirmed — ACK timeout for packet %d' % seq)
                      return
                  p['retry'] += 1
                  self._event('tx', 'Retry packet %d (%d/%d)' %
                              (seq, p['retry'], self.retries), t)
              else:
                  seq = next((s for s, p in t['pending'].items() if p['sent'] is None), None)
                  if seq is None:
                      return
                  p = t['pending'][seq]
              p['sent'] = now  # Timestamp PDU submission, not an RF hardware timestamp.
              self.next_emit = now + self.interval
              self.emit(p['wire'])

          def receive(self, frame):
              # The upstream CRC Check must drop failures and remove the CRC bytes.
              if len(frame) < 5 or len(frame) > 4092 or frame[:4] != self.peer + self.me:
                  return
              try:
                  raw = self.cipher.decrypt(frame[4:])
                  if len(raw) < _HEADER.size:
                      return
                  magic, typ, src, dst, tid, seq = _HEADER.unpack(raw[:_HEADER.size])
                  if magic != _MAGIC or src != self.peer or dst != self.me:
                      return
                  body = raw[_HEADER.size:]
              except (InvalidToken, ValueError, struct.error):
                  return
              if typ == _ACK:
                  self._acknowledge(tid, seq, body)
              elif typ == _ERROR:
                  if self.tx and tid == self.tx['tid'] and seq in self.tx['pending']:
                      self._abort_tx('Failed: ' + body.decode('utf-8', 'replace')[:180])
              elif typ == _CANCEL:
                  if body:
                      return
                  if self.rx and self.rx['tid'] == tid:
                      self._drop_rx('Cancelled by sender')
                  elif tid not in self.receipts:
                      # A reordered CANCEL can arrive before its META.
                      self._remember(tid, error='Cancelled by sender')
              elif typ in (_META, _DATA, _END):
                  try:
                      self._receive_data(typ, tid, seq, body)
                  except (ValueError, OSError, UnicodeError, KeyError, TypeError) as exc:
                      reason = str(exc)[:180]
                      if self.rx and self.rx['tid'] == tid:
                          self._drop_rx('Failed: ' + reason)
                      elif tid not in self.receipts:
                          self._remember(tid, error=reason)
                      self._reply(_ERROR, tid, seq, reason.encode('utf-8')[:180])

          def _remember(self, tid, **fields):
              self.receipts[tid] = dict(at=self.clock(), **fields)
              self.receipts.move_to_end(tid)
              while len(self.receipts) > 256:
                  self.receipts.popitem(last=False)

          def _receive_data(self, typ, tid, seq, body):
              if tid in self.receipts:
                  c = self.receipts[tid]
                  if 'error' in c:
                      self._reply(_ERROR, tid, seq, c['error'].encode('utf-8')[:180])
                  elif typ == _END and seq == c['seq'] and body == c['digest']:
                      self._reply(_ACK, tid, seq)  # Lost final ACK: never save twice.
                  return
              if typ == _META:
                  if seq != 0:
                      raise ValueError('Invalid metadata sequence')
                  if self.rx:
                      if self.rx['tid'] == tid and self.rx['meta'] == body:
                          self.rx['last'] = self.clock()
                          self._reply(_ACK, tid, seq)
                          return
                      raise ValueError('Receiver busy; retry after its current transfer')
                  meta = json.loads(body.decode('utf-8'))
                  if not isinstance(meta, dict):
                      raise ValueError('Invalid metadata')
                  size, chunk, window = meta.get('size'), meta.get('chunk'), meta.get('window')
                  digest, kind = meta.get('sha256'), meta.get('kind')
                  if type(size) is not int or not 0 <= size <= self.limit:
                      raise ValueError('Unsupported file size')
                  if type(chunk) is not int or not 128 <= chunk <= 1024:
                      raise ValueError('Invalid chunk size')
                  if type(window) is not int or not 1 <= window <= 32:
                      raise ValueError('Invalid window size')
                  if kind not in ('text', 'image', 'audio') or (kind == 'text' and size > 65536):
                      raise ValueError('Unsupported content type or text size')
                  if not isinstance(digest, str) or not re.fullmatch('[0-9a-f]{64}', digest):
                      raise ValueError('Invalid SHA-256')
                  if not isinstance(meta.get('name'), str) or len(meta['name']) > 200:
                      raise ValueError('Invalid filename')
                  self.directory.mkdir(parents=True, exist_ok=True)
                  f = tempfile.NamedTemporaryFile(mode='w+b', prefix='.incoming_',
                                                  suffix='.part', dir=self.directory, delete=False)
                  self.rx = dict(tid=tid, meta=body, kind=kind, name=self._safe_name(meta['name']),
                                 size=size, chunk=chunk, window=window, digest=digest,
                                 n=(size + chunk - 1) // chunk, next=1, done=0, buffer={},
                                 hash=hashlib.sha256(), file=f, temp=Path(f.name),
                                 started=self.clock(), last=self.clock())
                  self._event('rx', 'Receiving', self.rx)
                  self._reply(_ACK, tid, seq)
                  return
              r = self.rx
              if r is None or r['tid'] != tid:
                  raise ValueError('No matching transfer; send again from the beginning')
              r['last'] = self.clock()
              if typ == _DATA:
                  if not 1 <= seq <= r['n']:
                      raise ValueError('Invalid data sequence')
                  expected = min(r['chunk'], r['size'] - (seq - 1) * r['chunk'])
                  if len(body) != expected:
                      raise ValueError('Invalid chunk length')
                  if seq < r['next']:
                      self._reply(_ACK, tid, seq)  # Re-ACK without writing twice.
                      return
                  if seq >= r['next'] + r['window']:
                      return  # Out of receive window: do not ACK unretained data.
                  if seq not in r['buffer']:
                      r['buffer'][seq] = body
                      r['done'] += len(body)  # Unique accepted bytes, including buffered ones.
                  elif r['buffer'][seq] != body:
                      raise ValueError('Conflicting duplicate packet')
                  while r['next'] in r['buffer']:
                      contiguous = r['buffer'].pop(r['next'])
                      r['file'].write(contiguous)
                      r['hash'].update(contiguous)
                      r['next'] += 1
                  self._event('rx', 'Receiving', r)
                  self._reply(_ACK, tid, seq)
              elif typ == _END:
                  if seq != r['n'] + 1 or r['next'] != seq or r['done'] != r['size'] or r['buffer']:
                      raise ValueError('Incomplete file')
                  if body != bytes.fromhex(r['digest']) or r['hash'].hexdigest() != r['digest']:
                      raise ValueError('Whole-file SHA-256 mismatch')
                  r['file'].flush()
                  os.fsync(r['file'].fileno())
                  r['file'].close()
                  final = self.directory / (tid.hex() + '_' + r['name'])
                  os.replace(r['temp'], final)
                  self._remember(tid, seq=seq, digest=body)
                  self.rx = None
                  self._reply(_ACK, tid, seq)
                  self._event('rx', 'Complete — saved and verified', r, path=str(final))

          def tick(self):
              self._pump()
              now = self.clock()
              if self.rx and now - self.rx['last'] >= self.idle_timeout:
                  self._drop_rx('Timed out — partial file removed')
              for tid, entry in list(self.receipts.items()):
                  if now - entry['at'] > self.receipt_ttl:
                      del self.receipts[tid]

          def _abort_tx(self, reason):
              if self.tx:
                  t, self.tx = self.tx, None
                  self._reply(_CANCEL, t['tid'], 0)
                  self._event('tx', reason, t)

          def cancel(self):
              self._abort_tx('Cancelled — peer may have received some data')

          def _drop_rx(self, reason):
              r, self.rx = self.rx, None
              if r:
                  self._remember(r['tid'], error=reason)
                  try:
                      r['file'].close()
                  except OSError:
                      pass
                  try:
                      r['temp'].unlink(missing_ok=True)
                  except OSError as exc:
                      reason += '; partial-file cleanup failed: ' + str(exc)
                  self._event('rx', reason, r)

          def close(self):
              self.tx = None
              self._drop_rx('Stopped — partial file removed')


      class _WindowBridge(QtCore.QObject):
          open_requested = QtCore.pyqtSignal()
          close_requested = QtCore.pyqtSignal()

          def __init__(self, block):
              super().__init__()
              self.block, self.window = block, None
              self.open_requested.connect(self.open_window, QtCore.Qt.QueuedConnection)
              self.close_requested.connect(self.close_window, QtCore.Qt.QueuedConnection)

          @QtCore.pyqtSlot()
          def open_window(self):
              if not self.block.halt.is_set():
                  self.window = _TransferWindow(self.block)
                  self.window.show()

          @QtCore.pyqtSlot()
          def close_window(self):
              if self.window:
                  self.window.timer.stop()
                  self.window.allow_close = True
                  self.window.close()
                  self.window.deleteLater()
                  self.window = None


      class _TransferWindow(QtWidgets.QWidget):
          """Chat view only. Packet handling stays in _TransferCore."""
          def __init__(self, block):
              super().__init__()
              self.block, self.allow_close = block, False
              self.tx_bubble = self.rx_bubble = None
              self.messages = []
              self.setWindowTitle('Chat | %s → %s' % (block.my_addr, block.peer_addr))
              self.resize(570, 780)
              self.setMinimumSize(440, 540)
              self.setStyleSheet('''
                  QWidget { color:#173b32; font-family:Sans; font-size:14px; }
                  QWidget#chat, QWidget#historyBody { background:#f3f1eb; }
                  QFrame#header, QFrame#composer { background:white; }
                  QLabel { background:transparent; }
                  QLabel#avatar { background:#128c7e; color:white; border-radius:23px;
                      font-size:18px; font-weight:600; }
                  QLabel#name { font-size:18px; font-weight:600; }
                  QLabel#secondary { color:#77847e; font-size:11px; }
                  QLabel#day { color:#7b8780; font-size:11px; padding:10px; }
                  QFrame#sent { background:#d9fdd3; border:1px solid #ccecc6; border-radius:14px; }
                  QFrame#received { background:white; border:1px solid #e1e6e2; border-radius:14px; }
                  QPlainTextEdit { background:#f4f6f4; border:1px solid #e7ebe7;
                      border-radius:20px; padding:8px; font-size:14px; }
                  QPushButton,QToolButton { background:#e8f3ed; border:0; border-radius:16px;
                      padding:8px 12px; color:#16785c; }
                  QPushButton:hover,QToolButton:hover { background:#d1eadd; }
                  QPushButton#send { background:#128c7e; color:white; font-weight:600; }
                  QToolButton#attach { background:transparent; font-size:28px; padding:0; }
                  QToolButton::menu-indicator { image:none; }
                  QPushButton:disabled,QToolButton:disabled { color:#a4b8ac; background:#e7ede8; }
                  QPushButton#file { background:transparent; text-align:left; padding:5px 0; }
                  QPushButton#cancel { background:transparent; color:#886958; padding:2px; font-size:11px; }
                  QMenu { background:white; border:1px solid #d7e3da; padding:6px; }
                  QMenu::item { padding:9px 22px; }
                  QMenu::item:selected { background:#e6f4eb; }
                  QProgressBar { background:#e7eae1; border:0; border-radius:3px; }
                  QProgressBar::chunk { background:#20a47d; border-radius:3px; }
                  QScrollArea { background:transparent; border:0; }
                  QScrollBar:vertical { width:6px; background:transparent; }
                  QScrollBar::handle:vertical { background:#cdd6cc; border-radius:3px; min-height:24px; }
                  QScrollBar::add-line:vertical,QScrollBar::sub-line:vertical { height:0; }
              ''')
              self.setObjectName('chat')
              root = QtWidgets.QVBoxLayout(self)
              root.setContentsMargins(0, 0, 0, 0)
              root.setSpacing(0)

              header = QtWidgets.QFrame()
              header.setObjectName('header')
              top = QtWidgets.QHBoxLayout(header)
              top.setContentsMargins(20, 16, 18, 16)
              avatar = QtWidgets.QLabel(block.peer_addr)
              avatar.setObjectName('avatar')
              avatar.setAlignment(QtCore.Qt.AlignCenter)
              avatar.setFixedSize(46, 46)
              top.addWidget(avatar)
              contact = QtWidgets.QVBoxLayout()
              contact.setSpacing(4)
              name = QtWidgets.QLabel('Chat with ' + block.peer_addr)
              name.setObjectName('name')
              subtitle = QtWidgets.QLabel('Your node: ' + block.my_addr)
              subtitle.setObjectName('secondary')
              contact.addWidget(name)
              contact.addWidget(subtitle)
              top.addLayout(contact, 1)
              files = QtWidgets.QPushButton('Received files')
              files.clicked.connect(self.open_folder)
              top.addWidget(files)
              root.addWidget(header)

              self.scroll = QtWidgets.QScrollArea()
              self.scroll.setWidgetResizable(True)
              self.scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              body = QtWidgets.QWidget()
              body.setObjectName('historyBody')
              self.history = QtWidgets.QVBoxLayout(body)
              self.history.setContentsMargins(16, 4, 16, 14)
              self.history.setSpacing(12)
              self.history.setSizeConstraint(QtWidgets.QLayout.SetMinAndMaxSize)
              day = QtWidgets.QLabel('TODAY')
              day.setObjectName('day')
              day.setAlignment(QtCore.Qt.AlignCenter)
              self.history.addWidget(day)
              self.history.addStretch(1)
              self.scroll.setWidget(body)
              root.addWidget(self.scroll, 1)

              composer = QtWidgets.QFrame()
              composer.setObjectName('composer')
              controls = QtWidgets.QVBoxLayout(composer)
              controls.setContentsMargins(12, 12, 16, 9)
              row = QtWidgets.QHBoxLayout()
              row.setSpacing(8)
              self.attach = QtWidgets.QToolButton()
              self.attach.setObjectName('attach')
              self.attach.setText('+')
              self.attach.setToolTip('Send an image or audio file')
              self.attach.setAccessibleName('Attach image or audio file')
              self.attach.setFixedSize(38, 44)
              menu = QtWidgets.QMenu(self.attach)
              menu.addAction('Image…', lambda: self.choose('image'))
              menu.addAction('Audio file…', lambda: self.choose('audio'))
              self.attach.setMenu(menu)
              self.attach.setPopupMode(QtWidgets.QToolButton.InstantPopup)
              self.text = QtWidgets.QPlainTextEdit()
              self.text.setPlaceholderText('Type a message…')
              self.text.setFixedHeight(60)
              self.text.installEventFilter(self)
              self.send_button = QtWidgets.QPushButton('Send')
              self.send_button.setObjectName('send')
              self.send_button.setFixedSize(68, 44)
              self.send_button.clicked.connect(self.send_text)
              row.addWidget(self.attach)
              row.addWidget(self.text, 1)
              row.addWidget(self.send_button)
              controls.addLayout(row)
              self.hint = QtWidgets.QLabel('Enter to send · Shift+Enter for a new line')
              self.hint.setObjectName('secondary')
              self.hint.setAlignment(QtCore.Qt.AlignCenter)
              self.hint.setWordWrap(True)
              controls.addWidget(self.hint)
              root.addWidget(composer)
              self.timer = QtCore.QTimer(self)
              self.timer.timeout.connect(self.poll)
              self.timer.start(50)

          def eventFilter(self, obj, event):
              if obj is self.text and event.type() == QtCore.QEvent.KeyPress:
                  if event.key() in (QtCore.Qt.Key_Return, QtCore.Qt.Key_Enter):
                      if not event.modifiers() & QtCore.Qt.ShiftModifier:
                          self.send_text()
                          return True
              return super().eventFilter(obj, event)

          def send_text(self):
              if self.send_button.isEnabled() and self.text.toPlainText().strip():
                  if self.submit('text', self.text.toPlainText()):
                      self.text.clear()

          def choose(self, kind):
              filters = ('Images (*.png *.jpg *.jpeg *.bmp *.gif *.webp);;All files (*)'
                         if kind == 'image' else
                         'Audio (*.wav *.mp3 *.ogg *.flac *.m4a *.aac);;All files (*)')
              path, _ = QtWidgets.QFileDialog.getOpenFileName(self, 'Choose ' + kind + ' to send', '', filters)
              if path:
                  self.submit(kind, path)

          def submit(self, kind, value):
              if self.tx_bubble is not None:
                  return False
              try:
                  self.block.commands.put_nowait(('send', kind, value))
              except queue.Full:
                  self.hint.setText('Please try again in a moment.')
                  return False
              caption = value if kind == 'text' else Path(value).name
              self.tx_bubble = self.add_bubble(True, kind, caption)
              if kind != 'text':
                  self.show_file(self.tx_bubble, value)
              self.set_busy(True)
              return True

          def add_bubble(self, outgoing, kind, caption):
              row = QtWidgets.QWidget()
              layout = QtWidgets.QHBoxLayout(row)
              layout.setContentsMargins(0, 0, 0, 0)
              card = QtWidgets.QFrame()
              card.setObjectName('sent' if outgoing else 'received')
              card.setMaximumWidth(max(260, int(self.width() * 0.73)))
              card.setSizePolicy(QtWidgets.QSizePolicy.Preferred, QtWidgets.QSizePolicy.Maximum)
              content = QtWidgets.QVBoxLayout(card)
              content.setContentsMargins(13, 11, 13, 9)
              content.setSpacing(7)
              label = QtWidgets.QLabel()
              label.setTextFormat(QtCore.Qt.PlainText)
              label.setText(caption[:4096] + ('\n[Preview shortened]' if len(caption) > 4096 else ''))
              label.setWordWrap(True)
              label.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              label.setMinimumWidth(150)
              content.addWidget(label)
              preview = QtWidgets.QLabel()
              preview.setAlignment(QtCore.Qt.AlignCenter)
              preview.hide()
              content.addWidget(preview)
              open_button = QtWidgets.QPushButton('Play audio' if kind == 'audio' else 'Open file')
              open_button.setObjectName('file')
              open_button.hide()
              content.addWidget(open_button)
              progress = QtWidgets.QProgressBar()
              progress.setRange(0, 1000)
              progress.setValue(0)
              progress.setTextVisible(False)
              progress.setFixedHeight(5)
              content.addWidget(progress)
              footer = QtWidgets.QHBoxLayout()
              status = QtWidgets.QLabel('Preparing…' if outgoing else 'Receiving…')
              status.setObjectName('secondary')
              status.setTextFormat(QtCore.Qt.PlainText)
              status.setWordWrap(True)
              footer.addWidget(status, 1)
              cancel = QtWidgets.QPushButton('Cancel')
              cancel.setObjectName('cancel')
              cancel.setVisible(outgoing)
              cancel.clicked.connect(self.cancel_send)
              footer.addWidget(cancel)
              content.addLayout(footer)
              if outgoing:
                  layout.addStretch(1)
              layout.addWidget(card)
              if not outgoing:
                  layout.addStretch(1)
              self.history.insertWidget(self.history.count() - 1, row)
              record = dict(row=row, card=card, label=label, preview=preview, open=open_button,
                            bar=progress, status=status, cancel=cancel, kind=kind,
                            outgoing=outgoing, time=QtCore.QTime.currentTime().toString('HH:mm'),
                            path=None, state='Preparing', done=0, total=0)
              self.messages.append(record)
              # Bound widget memory; received files remain saved on disk.
              while len(self.messages) > 200:
                  old = next((m for m in self.messages if m is not self.tx_bubble and m is not self.rx_bubble), None)
                  if old is None:
                      break
                  self.messages.remove(old)
                  self.history.removeWidget(old['row'])
                  old['row'].deleteLater()
              QtCore.QTimer.singleShot(0, self.scroll_bottom)
              return record

          def show_file(self, bubble, path):
              bubble['path'] = path
              bubble['open'].setProperty('file_path', path)
              if not bubble.get('open_connected'):
                  bubble['open'].clicked.connect(self.open_file)
                  bubble['open_connected'] = True
              bubble['open'].show()
              if bubble['kind'] == 'image':
                  reader = QtGui.QImageReader(path)
                  size = reader.size()
                  if size.isValid() and size.width() * size.height() <= 40_000_000:
                      reader.setScaledSize(size.scaled(270, 170, QtCore.Qt.KeepAspectRatio))
                      picture = reader.read()
                      if not picture.isNull():
                          bubble['preview'].setPixmap(QtGui.QPixmap.fromImage(picture))
                          bubble['preview'].show()

          def open_file(self):
              path = self.sender().property('file_path')
              if path:
                  QtGui.QDesktopServices.openUrl(QtCore.QUrl.fromLocalFile(path))

          def cancel_send(self):
              try:
                  self.block.commands.put_nowait(('cancel',))
              except queue.Full:
                  self.hint.setText('Please try cancelling again in a moment.')

          def set_busy(self, busy):
              self.send_button.setEnabled(not busy)
              self.attach.setEnabled(not busy)
              self.hint.setText('Sending… You can type your next message.' if busy else
                                'Enter to send · Shift+Enter for a new line')

          def poll(self):
              bar = self.scroll.verticalScrollBar()
              following = bar.maximum() - bar.value() < 40
              changed = False
              for _ in range(300):
                  try:
                      event = self.block.events.get_nowait()
                  except queue.Empty:
                      break
                  self.display_event(event)
                  changed = True
              if changed and following:
                  QtCore.QTimer.singleShot(0, self.scroll_bottom)

          def display_event(self, e):
              direction, state = e['direction'], e['state']
              if direction == 'notice':
                  if self.tx_bubble:
                      b = self.tx_bubble
                      b['status'].setText(state)
                      b['state'] = state
                      b['bar'].hide()
                      b['cancel'].hide()
                      self.tx_bubble = None
                  self.set_busy(False)
                  self.hint.setText(state)
                  return
              outgoing = direction == 'tx'
              bubble = self.tx_bubble if outgoing else self.rx_bubble
              if bubble is None:
                  caption = 'Receiving message…' if e['kind'] == 'text' else e['name']
                  bubble = self.add_bubble(outgoing, e['kind'], caption)
                  if outgoing:
                      self.tx_bubble = bubble
                  else:
                      self.rx_bubble = bubble
              complete = state.startswith('Complete')
              active = state.startswith(('Sending', 'Receiving', 'Waiting', 'Retry'))
              percent = 100.0 if complete else min(99.9, 100.0 * e['done'] / max(1, e['total']))
              bubble.update(state=state, done=e['done'], total=e['total'])
              bubble['bar'].setValue(round(percent * 10))
              if complete:
                  if not outgoing:
                      path = e['path']
                      bubble['path'] = path
                      try:
                          if e['kind'] == 'text':
                              text = Path(path).read_text(encoding='utf-8')
                              bubble['label'].setText(text[:4096] + ('\n[Open file for the full message]' if len(text) > 4096 else ''))
                              if len(text) > 4096:
                                  self.show_file(bubble, path)
                          else:
                              self.show_file(bubble, path)
                      except (OSError, UnicodeError):
                          bubble['label'].setText('Saved file; preview unavailable.')
                          self.show_file(bubble, path)
                  bubble['status'].setText(bubble['time'] + ('  ·  ✓ Delivered' if outgoing else '  ·  Received'))
              elif active:
                  stage = ('Checking file…' if 'verification' in state else
                           state if state.startswith('Retry') else
                           'Sending' if outgoing else 'Receiving')
                  bubble['status'].setText('%s · %.1f%%' % (stage, percent))
              else:
                  bubble['status'].setText(state)
              if not active:
                  bubble['bar'].hide()
                  bubble['cancel'].hide()
                  if outgoing:
                      self.tx_bubble = None
                      self.set_busy(False)
                  else:
                      self.rx_bubble = None

          def scroll_bottom(self):
              bar = self.scroll.verticalScrollBar()
              bar.setValue(bar.maximum())

          def resizeEvent(self, event):
              super().resizeEvent(event)
              for message in self.messages:
                  message['card'].setMaximumWidth(max(260, int(self.width() * 0.73)))

          def open_folder(self):
              try:
                  Path(self.block.receive_dir).mkdir(parents=True, exist_ok=True)
                  QtGui.QDesktopServices.openUrl(QtCore.QUrl.fromLocalFile(self.block.receive_dir))
              except OSError as exc:
                  self.hint.setText(str(exc))

          def closeEvent(self, event):
              if self.allow_close:
                  event.accept()
              else:
                  self.showMinimized()
                  event.ignore()  # Use GRC Stop to close the flowgraph and both chats.
    ack_timeout: '1.0'
    chunk_size: '512'
    comment: GUI + TX/RX + file reassembly + stop-and-wait ARQ
    max_file_mb: '16'
    max_retries: '8'
    my_addr: my_addr
    packet_interval: '0.01'
    peer_addr: peer_addr
    receive_dir: '''./received_A1'''
    shared_key: shared_key
    show_gui: 'True'
    window_size: '5'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: variable_cc_decoder_def_0
    mtu: '1500'
    packed: 'True'
  states: {}
- name: fec_extended_async_encoder_0
  id: fec_extended_async_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '''11'''
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '1500000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2460000000'
    samplerate: samp_rate
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1500000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: '2420000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Contellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2460000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.42e9
    fftsize: '1024'
    name: '"Before AGC"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Before AGC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, fec_extended_async_encoder_0, in]
- [digital_crc_check_0_0, fail, blocks_message_debug_0, print_pdu]
- [digital_crc_check_0_0, ok, epy_transfer_gui, rx_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', qtgui_const_sink_x_2, '0']
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_transfer_gui, tx_out, digital_crc_append_0, in]
- [fec_async_decoder_0, out, digital_crc_check_0_0, in]
- [fec_extended_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, fec_async_decoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
