options:
  parameters:
    author: naagul
    description: Self-contained radio sources. Requires GNU Radio/IIO, NumPy, pyzmq, cryptography and g++. Set SDRCHAT_CONFIG to use your node JSON; otherwise the embedded coordinator configuration is used.
    generate_options: no_gui
    id: csma_transceiver
    output_language: python
    run_options: run
    title: Pixel Pulse · CSMA/CA QPSK NLMS
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fec_enabled
  id: variable
  parameters:
    comment: Enable/bypass on BOTH peers together; restart after changing.
    value: 'True'
  states: {}
- name: fec_log_every
  id: variable
  parameters:
    comment: Use 1 for every packet; 50 for file transfers.
    value: '50'
  states: {}
- name: fec_nsym
  id: variable
  parameters:
    comment: Parity bytes per codeword. Must match peer; restart after changing.
    value: '16'
  states: {}
- name: fec_verbose
  id: variable
  parameters:
    comment: Print corrections, failures and periodic packet counts.
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: radio_config["frequency"]
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: radio_config["sample_rate"]
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    constellation: digital.constellation_qpsk().base()
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """Add a repeatable prefix and a tail outside the packet header and payload."""

      import hashlib
      import os

      from gnuradio import gr
      import pmt


      def training_bytes(length):
          output = bytearray()
          counter = 0

          while len(output) < length:
              output.extend(
                  hashlib.sha256(
                      b"QPSK-training-v1" + counter.to_bytes(4, "big")
                  ).digest()
              )
              counter += 1

          return bytes(output[:length])


      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=1500, num_tail_bytes=1024):
              gr.basic_block.__init__(
                  self,
                  name="Burst Prefix + Tail",
                  in_sig=None,
                  out_sig=None,
              )

              self.prefix = int(num_dummy_bytes)
              self.tail = int(num_tail_bytes)

              if self.prefix < 0 or self.tail < 0:
                  raise ValueError("Padding lengths must be nonnegative")

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  return

              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              padded = (
                  training_bytes(self.prefix)
                  + raw
                  + os.urandom(self.tail)
              )

              output = pmt.cons(
                  pmt.car(msg),
                  pmt.init_u8vector(len(padded), list(padded)),
              )
              self.message_port_pub(pmt.intern("pdu_out"), output)
    comment: Random prefix for acquisition; tail flushes finite bursts
    num_dummy_bytes: '2048'
    num_tail_bytes: '2570'
  states: {}
- name: epy_mac_bridge
  id: epy_block
  parameters:
    _source_code: |
      # Pixel Pulse: all project radio modules are embedded below.
      # No sdrchat checkout or separately supplied Python blocks are required.
      import importlib.abc as _abc
      import importlib.util as _util
      import sys as _sys
      import types as _types

      _RADIO_SOURCES = {'config': 'import json\n'
                 'from pathlib import Path\n'
                 '\n'
                 '\n'
                 'def load(path):\n'
                 '    path = Path(path).resolve()\n'
                 '    c = json.loads(path.read_text())\n'
                 "    if not 1 <= c['address'] <= 65534:\n"
                 "        raise ValueError('Node address must be 0x0001..0xFFFE')\n"
                 "    c['state_dir'] = str((path.parent / c['state_dir']).resolve())\n"
                 "    c['config_path'] = str(path)\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n'
                 '\n'
                 '\n'
                 'def addr(value):\n'
                 "    return f'0x{int(value):04X}'\n"
                 '\n'
                 '\n'
                 "_DEFAULT_CONFIG = {'address': 16170, 'name': 'User 1', 'frequency': 2426500000, 'uri': "
                 "'ip:192.168.1.10', 'commands_port': 5555, 'events_port': 5556, 'shared_key': "
                 "'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=', 'state_dir': './data/node_a', 'sample_rate': "
                 "2400000, 'cs_threshold_db': -35.0, 'cs_hysteresis_db': 3.0, 'difs_s': 0.02, 'slot_s': 0.015, "
                 "'ack_timeout_s': 1.0, 'retry_limit': 20, 'cw_min': [8, 16, 32], 'cw_max': 1024, 'aging_s': 30.0, "
                 "'tx_delay_s': 0.02, 'tx_guard_s': 0.01, 'tx_attenuation_db': 0.0, 'rx_gain_db': 45, 'nlms_taps': "
                 "7, 'nlms_mu': 0.2, 'nlms_dd_mu': 0.02, 'nlms_eps': 1e-06, 'correlation_threshold': 0.6, "
                 "'contacts': [], 'local_radio_configured': True}\n"
                 '_original_load = load\n'
                 '\n'
                 'def load(path):\n'
                 '    import os\n'
                 '    path = Path(path)\n'
                 '    if path.exists():\n'
                 '        return _original_load(path)\n'
                 "    if os.environ.get('SDRCHAT_CONFIG') or str(path) != 'configs/node_a.json':\n"
                 "        raise FileNotFoundError('Node configuration does not exist: ' + str(path))\n"
                 '    c = dict(_DEFAULT_CONFIG)\n'
                 "    c['state_dir'] = str(Path(c['state_dir']).resolve())\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n',
       'engine': '"""Durable, single-flight ARQ with CSMA/CA. Owned by the radio process."""\n'
                 'import hashlib\n'
                 'import json\n'
                 'import random\n'
                 'import sqlite3\n'
                 'import time\n'
                 'import uuid\n'
                 'from collections import deque\n'
                 'from pathlib import Path\n'
                 'from cryptography.fernet import InvalidToken\n'
                 'from .protocol import Codec, TEXT, ACK, BROADCAST, make_fragment, parse_fragment\n'
                 '\n'
                 '\n'
                 'class Engine:\n'
                 '    def __init__(self, config, transmit, event, clock=time.monotonic, rng=None):\n'
                 "        self.c=config; self.me=config['address']; self.transmit=transmit; self.event=event\n"
                 '        self.clock=clock; self.rng=rng or random.SystemRandom(); '
                 "self.codec=Codec(config['shared_key'])\n"
                 "        self.db=sqlite3.connect(str(Path(config['state_dir'])/'radio.sqlite'))\n"
                 "        self.db.execute('PRAGMA journal_mode=WAL'); self.db.execute('PRAGMA synchronous=FULL')\n"
                 "        self.db.executescript('''\n"
                 '        CREATE TABLE IF NOT EXISTS jobs(id TEXT PRIMARY KEY,dst INTEGER,priority INTEGER,kind '
                 'TEXT,name TEXT,data BLOB,created REAL,status TEXT,part INTEGER DEFAULT 0);\n'
                 '        CREATE TABLE IF NOT EXISTS fragments(src INTEGER,id TEXT,part INTEGER,total INTEGER,meta '
                 'TEXT,data BLOB,PRIMARY KEY(src,id,part));\n'
                 '        CREATE TABLE IF NOT EXISTS receipts(src INTEGER,seq INTEGER,digest TEXT,PRIMARY '
                 'KEY(src,seq));\n'
                 '        CREATE TABLE IF NOT EXISTS received(src INTEGER,id TEXT,kind TEXT,name TEXT,data '
                 'BLOB,PRIMARY KEY(src,id));\n'
                 '        CREATE TABLE IF NOT EXISTS settings(key TEXT PRIMARY KEY,value INTEGER);\n'
                 "        ''')\n"
                 '        self.db.execute("INSERT OR IGNORE INTO settings '
                 'VALUES(\'sequence\',?)",(self.rng.randrange(1,2**30),))\n'
                 '        self.db.execute("UPDATE jobs SET status=\'queued\' WHERE status IN '
                 '(\'sending\',\'sent\')")\n'
                 '        self.db.commit()\n'
                 '        self.queues=[deque(),deque(),deque()]\n'
                 '        self.jobs={}; self.current=None; self.flight=None; self.acks=deque(); '
                 'self.ack_keys=set()\n'
                 '        self.contender=None; self.idle_since=None; self.tx_until=0; self.busy=True\n'
                 '        self.power=-200.; self.sense_at=-1e9; self.last_status=-1e9\n'
                 '        for row in self.db.execute("SELECT id,dst,priority,kind,name,data,created,part FROM jobs '
                 'WHERE status=\'queued\' ORDER BY created,rowid"):\n'
                 "            j=dict(zip(('id','dst','priority','kind','name','data','created','part'),row))\n"
                 "            j['enqueued']=self.clock()-max(0,time.time()-j['created']); self.jobs[j['id']]=j\n"
                 "            self.queues[j['priority']].append(j)\n"
                 '\n'
                 '    def close(self):\n'
                 '        self.db.close()\n'
                 '\n'
                 '    def status(self, ident, state, **extra):\n'
                 "        self.db.execute('UPDATE jobs SET status=? WHERE id=?',(state,ident)); self.db.commit()\n"
                 "        self.event(dict(event='status',id=ident,status='sent' if state=='broadcast_sent' else "
                 'state,**extra))\n'
                 '\n'
                 '    def enqueue(self, command):\n'
                 "        ident=str(uuid.UUID(command['id']))\n"
                 "        found=self.db.execute('SELECT status FROM jobs WHERE id=?',(ident,)).fetchone()\n"
                 '        if found:\n'
                 "            self.event(dict(event='status',id=ident,status='sent' if found[0]=='broadcast_sent' "
                 'else found[0])); return\n'
                 "        dst=int(command['dst']); pri=int(command['priority']); kind=command['kind']\n"
                 '        if dst==self.me or not 1<=dst<=BROADCAST or pri not in (0,1,2):\n'
                 "            raise ValueError('Invalid destination or priority')\n"
                 "        if kind=='text':\n"
                 "            data=command['text'].encode('utf-8'); name='message.txt'\n"
                 "            if not 0<len(data)<=65536: raise ValueError('Text must contain 1..65536 UTF-8 "
                 "bytes')\n"
                 "        elif kind in ('image','audio','file'):\n"
                 "            p=Path(command['path']).resolve()\n"
                 '            if not p.is_file() or not 0<p.stat().st_size<=16*1024*1024:\n'
                 "                raise ValueError('Choose a nonempty file up to 16 MiB')\n"
                 "            data=p.read_bytes(); name=str(command.get('name',p.name))[:120]\n"
                 "        else: raise ValueError('Unknown message type')\n"
                 '        j=dict(id=ident,dst=dst,priority=pri,kind=kind,name=name,data=data,\n'
                 '               created=time.time(),part=0,enqueued=self.clock())\n'
                 "        self.db.execute('INSERT INTO jobs VALUES(?,?,?,?,?,?,?,?,?)',\n"
                 "            (ident,dst,pri,kind,name,data,j['created'],'queued',0)); self.db.commit()\n"
                 '        self.jobs[ident]=j; self.queues[pri].append(j)\n'
                 "        self.status(ident,'queued')\n"
                 '\n'
                 '    def snapshot(self):\n'
                 "        for ident,status in self.db.execute('SELECT id,status FROM jobs'):\n"
                 "            self.event(dict(event='status',id=ident,status='sent' if status=='broadcast_sent' "
                 'else status))\n'
                 "        for src,ident,kind,name,data in self.db.execute('SELECT src,id,kind,name,data FROM "
                 "received'):\n"
                 '            self.deliver_event(src,ident,kind,name,data)\n'
                 '\n'
                 '    def deliver_event(self, src, ident, kind, name, data):\n'
                 "        info=dict(event='received',id=ident,src=src,kind=kind,name=name)\n"
                 "        if kind=='text': info['text']=data.decode('utf-8')\n"
                 '        else:\n'
                 "            directory=Path(self.c['state_dir'])/'received'; directory.mkdir(exist_ok=True)\n"
                 "            safe=''.join(c if c.isalnum() or c in '.-_ ' else '_' for c in "
                 'Path(name).name)[:120]\n'
                 "            path=directory/(str(src)+'_'+ident+'_'+safe)\n"
                 '            if not path.exists():\n'
                 '                '
                 "temp=path.with_suffix(path.suffix+'.part');temp.write_bytes(data);temp.replace(path)\n"
                 "            info['path']=str(path)\n"
                 '        self.event(info)\n'
                 '\n'
                 '    def sense(self, power_db, busy=None):\n'
                 '        self.power=float(power_db); self.sense_at=self.clock()\n'
                 '        if busy is None:\n'
                 "            limit=self.c['cs_threshold_db']-(self.c['cs_hysteresis_db'] if self.busy else 0)\n"
                 '            self.busy=self.power>limit\n'
                 '        else:self.busy=bool(busy)\n'
                 '        if self.busy:\n'
                 '            self.idle_since=None\n'
                 "            if self.contender:self.contender.pop('slot_at',None)\n"
                 '\n'
                 '    def receive(self, wire):\n'
                 '        try:\n'
                 '            f=self.codec.unpack(wire,self.me)\n'
                 "            if f['typ']==ACK:\n"
                 '                p=self.flight\n'
                 "                if p and p.get('sent_once') and f['dst']==self.me and f['src']==p['dst'] and "
                 "f['seq']==p['seq'] and f['body']==uuid.UUID(self.current['id']).bytes:\n"
                 '                    self.complete_packet()\n'
                 '                return\n'
                 '            digest=hashlib.sha256(wire).hexdigest()\n'
                 "            receipt=self.db.execute('SELECT digest FROM receipts WHERE src=? AND "
                 "seq=?',(f['src'],f['seq'])).fetchone()\n"
                 "            ident,index,count,meta,data=parse_fragment(f['body'])\n"
                 '            if receipt and receipt[0]!=digest: return\n'
                 '            if not receipt:\n'
                 '                # Completed messages may be retransmitted with a new sequence after a restart.\n'
                 "                done=self.db.execute('SELECT 1 FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 '                if not done:\n'
                 '                    m=json.dumps(meta,sort_keys=True)\n'
                 "                    existing=self.db.execute('SELECT meta,data FROM fragments WHERE src=? AND "
                 "id=? AND part=?',(f['src'],ident,index)).fetchone()\n"
                 "                    if existing and existing!=(m,data):raise ValueError('Conflicting fragment')\n"
                 "                    other=self.db.execute('SELECT meta FROM fragments WHERE src=? AND id=? LIMIT "
                 "1',(f['src'],ident)).fetchone()\n"
                 "                    if other and other[0]!=m:raise ValueError('Conflicting metadata')\n"
                 "                    self.db.execute('INSERT OR IGNORE INTO fragments "
                 "VALUES(?,?,?,?,?,?)',(f['src'],ident,index,count,m,data))\n"
                 "                    rows=self.db.execute('SELECT data FROM fragments WHERE src=? AND id=? ORDER "
                 "BY part',(f['src'],ident)).fetchall()\n"
                 '                    if len(rows)==count:\n'
                 "                        full=b''.join(r[0] for r in rows)\n"
                 "                        if len(full)!=meta['size'] or "
                 "hashlib.sha256(full).hexdigest()!=meta['sha256']:\n"
                 "                            raise ValueError('Whole-message SHA-256 failure')\n"
                 "                        if meta['kind']=='text':full.decode('utf-8')\n"
                 "                        self.db.execute('INSERT INTO received "
                 "VALUES(?,?,?,?,?)',(f['src'],ident,meta['kind'],meta['name'],full))\n"
                 "                        self.db.execute('DELETE FROM fragments WHERE src=? AND "
                 "id=?',(f['src'],ident))\n"
                 "                self.db.execute('INSERT INTO receipts "
                 "VALUES(?,?,?)',(f['src'],f['seq'],digest)); self.db.commit()\n"
                 '                # Reconstruct delivery event from durable storage, before acknowledging '
                 'completion.\n'
                 "                received=self.db.execute('SELECT kind,name,data FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 "                if received:self.deliver_event(f['src'],ident,*received)\n"
                 "            if f['dst']!=BROADCAST and (f['src'],f['seq']) not in self.ack_keys:\n"
                 "                self.ack_keys.add((f['src'],f['seq']))\n"
                 "                raw=self.codec.pack(f['src'],self.me,f['seq'],0,ACK,uuid.UUID(ident).bytes)\n"
                 '                '
                 "self.acks.append(dict(wire=raw,ack=True,dst=f['src'],seq=f['seq'],cw=4,slots=None))\n"
                 '        except (ValueError,KeyError,TypeError,InvalidToken,UnicodeError) as exc:\n'
                 '            self.db.rollback()\n'
                 "            self.event(dict(event='diagnostic',message='RX rejected: '+str(exc)))\n"
                 '\n'
                 '    def choose(self):\n'
                 '        now=self.clock()\n'
                 "        heads=[(max(0,p-int((now-q[0]['enqueued'])/self.c['aging_s'])),q[0]['created'],p) for "
                 'p,q in enumerate(self.queues) if q]\n'
                 '        if not heads:return None\n'
                 '        _,_,p=min(heads)\n'
                 '        return self.queues[p].popleft()\n'
                 '\n'
                 '    def new_packet(self):\n'
                 '        j=self.current\n'
                 '        seq=self.db.execute("SELECT value FROM settings WHERE key=\'sequence\'").fetchone()[0]\n'
                 "        if seq>=0xFFFFFFFF:raise RuntimeError('Sequence space exhausted; provision a new node "
                 "address')\n"
                 '        self.db.execute("UPDATE settings SET value=? WHERE '
                 'key=\'sequence\'",(seq+1,));self.db.commit()\n'
                 "        body,count=make_fragment(j,j['part'])\n"
                 "        self.flight=dict(wire=self.codec.pack(j['dst'],self.me,seq,j['priority'],TEXT,body),\n"
                 '                         '
                 "dst=j['dst'],seq=seq,retries=0,cw=self.c['cw_min'][j['priority']],slots=None,\n"
                 '                         deadline=None,ack=False,count=count)\n'
                 '\n'
                 '    def complete_packet(self):\n'
                 '        j=self.current;p=self.flight\n'
                 '        if self.contender is p:self.contender=None\n'
                 "        j['part']+=1\n"
                 "        self.db.execute('UPDATE jobs SET part=? WHERE "
                 "id=?',(j['part'],j['id']));self.db.commit()\n"
                 '        self.flight=None\n'
                 "        if j['part']>=p['count']:\n"
                 "            self.status(j['id'],'broadcast_sent' if j['dst']==BROADCAST else "
                 "'delivered',broadcast=j['dst']==BROADCAST)\n"
                 "            self.jobs.pop(j['id'],None);self.current=None\n"
                 '        else:\n'
                 "            self.status(j['id'],'sending',progress=j['part']/p['count'])\n"
                 "            self.queues[j['priority']].appendleft(j);self.current=None\n"
                 '\n'
                 '    def tick(self):\n'
                 '        now=self.clock()\n'
                 '        if now-self.last_status>=0.5:\n'
                 "            self.event(dict(event='telemetry',power_db=self.power,busy=self.busy,\n"
                 '                            waiting=sum(map(len,self.queues)),active=bool(self.current),\n'
                 '                            queues=[len(q) for q in self.queues],address=self.me))\n'
                 '            self.last_status=now\n'
                 '        if now<self.tx_until:\n'
                 '            self.idle_since=None;return\n'
                 "        if self.flight and self.flight.get('broadcast_done'):\n"
                 '            self.complete_packet()\n'
                 "        if self.flight and self.flight['deadline'] is not None and "
                 "now>=self.flight['deadline']:\n"
                 '            p=self.flight\n'
                 "            if p['retries']>=self.c['retry_limit']:\n"
                 "                self.status(self.current['id'],'failed',reason='ACK timeout: retry limit "
                 "reached')\n"
                 "                self.jobs.pop(self.current['id'],None);self.current=None;self.flight=None\n"
                 '                if self.contender is p:self.contender=None\n'
                 '            else:\n'
                 "                p['retries']+=1;p['cw']=min(self.c['cw_max'],p['cw']*2)\n"
                 "                p['deadline']=None;p['slots']=None\n"
                 "                self.status(self.current['id'],'sending',retry=p['retries'])\n"
                 '        if self.current is None:\n'
                 '            self.current=self.choose()\n'
                 '        if self.current and self.flight is None:self.new_packet()\n'
                 '        # ACKs have a separate control queue. They never wait behind a data ACK timeout.\n'
                 '        if self.acks:\n'
                 '            candidate=self.acks[0]\n'
                 "        elif self.flight and self.flight['deadline'] is None:\n"
                 '            candidate=self.flight\n'
                 '        else:\n'
                 '            self.contender=None;return\n'
                 '        if candidate is not self.contender:\n'
                 "            self.contender=candidate; self.idle_since=None;candidate.pop('slot_at',None)\n"
                 '        if self.busy or now-self.sense_at>0.2:\n'
                 "            self.idle_since=None;candidate.pop('slot_at',None);return\n"
                 '        if self.idle_since is None:self.idle_since=now\n'
                 "        if now-self.idle_since<self.c['difs_s']:return\n"
                 "        if candidate['slots'] is None:\n"
                 "            candidate['slots']=self.rng.randrange(candidate['cw']);candidate['slot_at']=now\n"
                 "        elif 'slot_at' not in candidate:candidate['slot_at']=now\n"
                 "        slots=int((now-candidate['slot_at'])/self.c['slot_s'])\n"
                 "        candidate['slots']=max(0,candidate['slots']-slots)\n"
                 "        candidate['slot_at']+=slots*self.c['slot_s']\n"
                 "        if candidate['slots']:return\n"
                 "        if not candidate['ack']:self.status(self.current['id'],'sending')\n"
                 "        try:duration=float(self.transmit(candidate['wire']))\n"
                 '        except Exception as exc:\n'
                 "            self.event(dict(event='diagnostic',message='TX unavailable: '+str(exc)))\n"
                 "            candidate['slots']=None;self.idle_since=None;return\n"
                 '        self.tx_until=now+duration;self.idle_since=None;self.contender=None\n'
                 "        if candidate['ack']:\n"
                 "            self.acks.popleft();self.ack_keys.discard((candidate['dst'],candidate['seq']))\n"
                 '        else:\n'
                 "            candidate['sent_once']=True\n"
                 "            candidate['deadline']=self.tx_until+self.c['ack_timeout_s']\n"
                 "            if candidate['dst']==BROADCAST:candidate['broadcast_done']=True\n"
                 "            self.status(self.current['id'],'sent',retry=candidate['retries'])\n",
       'equalizer': 'import ctypes\n'
                    'import hashlib\n'
                    'from pathlib import Path\n'
                    'import numpy as np\n'
                    'import pmt\n'
                    'from gnuradio import gr\n'
                    '\n'
                    '\n'
                    'def training_bytes(length=2048):\n'
                    "    return b''.join(hashlib.sha256(b'QPSK-training-v1'+i.to_bytes(4,'big')).digest()\n"
                    '                    for i in range((length+31)//32))[:length]\n'
                    '\n'
                    '\n'
                    'def training_symbols():\n'
                    '    # Last 64 bytes of the EXISTING deterministic prefix. Constant differential\n'
                    '    # phase before this segment is absorbed by training; no change to TX bytes.\n'
                    '    bits=np.unpackbits(np.frombuffer(training_bytes()[-64:],dtype=np.uint8)).reshape(-1,2)\n'
                    '    chunks=bits[:,0]*2+bits[:,1]\n'
                    '    mapped=np.array([0,1,3,2])[chunks]\n'
                    '    index=np.cumsum(mapped)%4\n'
                    '    return np.array([.707+.707j,-.707+.707j,-.707-.707j,.707-.707j],np.complex64)[index]\n'
                    '\n'
                    '\n'
                    'class TrainingCorrelator(gr.sync_block):\n'
                    '    def __init__(self, threshold=.6):\n'
                    "        gr.sync_block.__init__(self,name='QPSK training "
                    "correlator',in_sig=[np.complex64],out_sig=[np.complex64])\n"
                    '        symbols=training_symbols()[:64]\n'
                    '        t=np.arange(-8,9)/2.;a=.35\n'
                    '        pulse=np.sinc(t)*np.cos(np.pi*a*t)/(1-(2*a*t)**2)\n'
                    '        '
                    'self.ref=np.convolve(np.kron(symbols,[1,0]),pulse)[8:8+2*len(symbols)-1].astype(np.complex64)\n'
                    '        self.energy=float(np.vdot(self.ref,self.ref).real);self.threshold=threshold\n'
                    '        self.delay=(len(self.ref)+9)//2*2\n'
                    '        self.set_history(self.delay+1);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '        self.next_position=0;self.last_position=-10000;self.count=0\n'
                    '\n'
                    '    def work(self, inputs, outputs):\n'
                    '        x=inputs[0];out=outputs[0];n=len(out);out[:]=x[:n]\n'
                    '        base=self.nitems_written(0)-self.delay\n'
                    "        c=np.correlate(x,self.ref,'valid')\n"
                    "        power=np.convolve(np.abs(x).astype(np.float64)**2,np.ones(len(self.ref)),'valid')\n"
                    '        score=np.abs(c)**2/(self.energy*power+1e-12)\n'
                    '        '
                    'lo=max(self.next_position-base,2,-base);hi=min(len(score)-3,n+self.delay-len(self.ref))\n'
                    '        for j in np.flatnonzero(score[lo:hi+1]>self.threshold)+lo:\n'
                    '            if score[j]<max(score[j-2:j]) or score[j]<=max(score[j+1:j+3]):continue\n'
                    '            absolute=base+int(j)\n'
                    '            if absolute-self.last_position<512:continue\n'
                    '            offset=absolute+self.delay\n'
                    '            if offset<self.nitems_written(0):continue\n'
                    '            '
                    "self.add_item_tag(0,offset,pmt.intern('corr_est'),pmt.from_double(float(score[j])))\n"
                    '            self.last_position=absolute;self.count+=1\n'
                    '        if hi>=lo:self.next_position=base+hi+1\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    'class NLMS(gr.decim_block):\n'
                    '    def __init__(self,taps=7,mu=.2,dd_mu=.02,eps=1e-6):\n'
                    "        gr.decim_block.__init__(self,name='Regularized QPSK "
                    "NLMS',in_sig=[np.complex64],out_sig=[np.complex64],decim=2)\n"
                    '        if taps<3 or taps%2!=1 or not 0<mu<2 or not 0<dd_mu<2 or eps<=0:raise '
                    "ValueError('Invalid NLMS parameters')\n"
                    '        self.taps=taps;self.mu=mu;self.dd_mu=dd_mu;self.eps=eps\n'
                    '        self.weights=np.zeros(taps,np.complex64);self.weights[0]=1\n'
                    '        '
                    'self.training=training_symbols();self.pos=ctypes.c_int(0);self.active=ctypes.c_int(0)\n'
                    '        lib=_embedded_native_library()\n'
                    "        if not lib.exists():raise RuntimeError('Run ./setup.sh to build the NLMS kernel')\n"
                    '        self.lib=ctypes.CDLL(str(lib));self.fn=self.lib.nlms_process\n'
                    '        '
                    'self.fn.argtypes=[ctypes.c_void_p,ctypes.c_void_p,ctypes.c_int,ctypes.c_int,ctypes.c_void_p,\n'
                    '            '
                    'ctypes.c_void_p,ctypes.c_int,ctypes.POINTER(ctypes.c_int),ctypes.POINTER(ctypes.c_int),\n'
                    '            '
                    'ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_void_p,ctypes.c_int]\n'
                    '        '
                    'self.fn.restype=None;self.set_history(taps);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '\n'
                    '    def work(self,inputs,outputs):\n'
                    '        x=inputs[0];y=outputs[0];n=len(y)\n'
                    "        tags=self.get_tags_in_window(0,0,2*n,pmt.intern('corr_est'))\n"
                    '        starts=np.array([int(t.offset-self.nitems_read(0)) for t in tags],np.int32)\n'
                    '        self.fn(x.ctypes.data,y.ctypes.data,n,self.taps,self.weights.ctypes.data,\n'
                    '                '
                    'self.training.ctypes.data,len(self.training),ctypes.byref(self.pos),ctypes.byref(self.active),\n'
                    '                self.mu,self.dd_mu,self.eps,1e-8,starts.ctypes.data,len(starts))\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    "_NATIVE_SOURCE = '// Batched regularized complex NLMS. y = w^H x, e = d-y.\\n#include "
                    '<complex>\\n#include <cmath>\\n#include <algorithm>\\nusing C = std::complex<float>;\\nextern '
                    '"C" void nlms_process(const C* input, C* output, int n, int '
                    'taps,\\n                              C* weights, const C* training, int '
                    'training_len,\\n                              int* training_pos, int* active, float '
                    'mu,\\n                              float dd_mu, float eps, float '
                    'gate,\\n                              const int* starts, int nstarts) {\\n    int '
                    'tag=0;\\n    for(int i=0;i<n;i++) {\\n        if(tag<nstarts && starts[tag]<=2*i+1) '
                    '{\\n            *training_pos=0;*active=1;tag++;\\n            '
                    'std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);\\n        }\\n        const C* '
                    'newest=input+taps-1+2*i;\\n        C y(0,0);float power=0;\\n        for(int k=0;k<taps;k++) '
                    '{y+=std::conj(weights[k])*newest[-k];power+=std::norm(newest[-k]);}\\n        '
                    'output[i]=y;\\n        if(!*active || power<gate || !std::isfinite(power))continue;\\n        '
                    'bool train=*training_pos<training_len;\\n        C '
                    'desired=train?training[(*training_pos)++]:C(y.real()>=0?.707f:-.707f,y.imag()>=0?.707f:-.707f);\\n        '
                    'C error=desired-y;\\n        float step=(train?mu:dd_mu)/(eps+power);\\n        for(int '
                    'k=0;k<taps;k++)weights[k]+=step*std::conj(error)*newest[-k];\\n        // Disable adaptation '
                    'on catastrophic divergence; reacquire on next preamble.\\n        '
                    'if(!std::isfinite(std::norm(y)) || std::norm(y)>1e6f) '
                    "{*active=0;std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);}\\n    }\\n}\\n'\n"
                    '_native_directory = None\n'
                    '\n'
                    'def _embedded_native_library():\n'
                    '    global _native_directory\n'
                    '    import shutil\n'
                    '    import subprocess\n'
                    '    import tempfile\n'
                    '    if _native_directory is None:\n'
                    "        compiler = shutil.which('g++')\n"
                    '        if compiler is None:\n'
                    "            raise RuntimeError('The embedded NLMS source needs g++. Install g++ and run "
                    "again.')\n"
                    "        directory = tempfile.TemporaryDirectory(prefix='pixel-pulse-nlms-')\n"
                    '        folder = Path(directory.name)\n'
                    "        source = folder / 'nlms.cpp'\n"
                    '        source.write_text(_NATIVE_SOURCE)\n'
                    '        try:\n'
                    "            subprocess.run([compiler, '-O3', '-std=c++17', '-shared', '-fPIC', str(source), "
                    "'-o', str(folder / 'libnlms.so')], check=True, capture_output=True, text=True)\n"
                    '        except subprocess.CalledProcessError as exc:\n'
                    '            directory.cleanup()\n'
                    "            raise RuntimeError('Could not compile embedded NLMS source: ' + exc.stderr) from "
                    'exc\n'
                    '        _native_directory = directory\n'
                    "    return Path(_native_directory.name) / 'libnlms.so'\n",
       'protocol': '"""Network-order routing header + authenticated encrypted fragment or ACK.\n'
                   '\n'
                   'The GNU Radio graph adds CRC32 and RS outside this layer. The simulator uses\n'
                   'the same CRC and RS codec. Routing fields are repeated inside Fernet so they\n'
                   'cannot be altered without authentication failure.\n'
                   '"""\n'
                   'import hashlib\n'
                   'import json\n'
                   'import struct\n'
                   'import uuid\n'
                   'import zlib\n'
                   'from cryptography.fernet import Fernet\n'
                   'from .reedsolo_bundled import RSCodec\n'
                   '\n'
                   'TEXT, ACK = 1, 2\n'
                   'BROADCAST = 0xFFFF\n'
                   "HEADER = struct.Struct('!HHIBBH')\n"
                   "ROUTE = struct.Struct('!HHIBB')\n"
                   "FRAGMENT = struct.Struct('!16sHHH')\n"
                   '\n'
                   '\n'
                   'class Codec:\n'
                   '    def __init__(self, key):\n'
                   '        self.cipher = Fernet(key.encode() if isinstance(key, str) else key)\n'
                   '        self.rs = RSCodec(16, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8)\n'
                   '\n'
                   '    def pack(self, dst, src, seq, priority, typ, body):\n'
                   '        if not 1 <= src < BROADCAST or not 1 <= dst <= BROADCAST:\n'
                   "            raise ValueError('Invalid address')\n"
                   '        if priority not in (0, 1, 2) or typ not in (TEXT, ACK):\n'
                   "            raise ValueError('Invalid priority or packet type')\n"
                   '        route = ROUTE.pack(dst, src, seq, priority, typ)\n'
                   '        token = self.cipher.encrypt(route + body)\n'
                   '        wire = HEADER.pack(dst, src, seq, priority, typ, len(token)) + token\n'
                   '        if len(wire) > 4092:\n'
                   "            raise ValueError('Frame exceeds original 4092-byte budget')\n"
                   '        return wire\n'
                   '\n'
                   '    def unpack(self, wire, me):\n'
                   '        if len(wire) < HEADER.size or len(wire) > 4092:\n'
                   "            raise ValueError('Invalid frame size')\n"
                   '        dst, src, seq, pri, typ, length = HEADER.unpack_from(wire)\n'
                   '        if dst not in (me, BROADCAST) or src == me or not 1 <= src < BROADCAST:\n'
                   "            raise ValueError('Frame for another node or own echo')\n"
                   '        if length != len(wire)-HEADER.size or pri not in (0,1,2) or typ not in (TEXT,ACK):\n'
                   "            raise ValueError('Malformed header')\n"
                   '        raw = self.cipher.decrypt(wire[HEADER.size:])\n'
                   '        if raw[:ROUTE.size] != ROUTE.pack(dst,src,seq,pri,typ):\n'
                   "            raise ValueError('Authenticated routing mismatch')\n"
                   '        return dict(dst=dst, src=src, seq=seq, priority=pri, typ=typ, body=raw[ROUTE.size:])\n'
                   '\n'
                   '    def protect(self, raw):\n'
                   "        data = raw + struct.pack('!I', zlib.crc32(raw))\n"
                   '        return bytes(self.rs.encode(data))\n'
                   '\n'
                   '    def recover(self, coded):\n'
                   '        data = bytes(self.rs.decode(coded)[0])\n'
                   "        if len(data)<4 or zlib.crc32(data[:-4]) != struct.unpack('!I',data[-4:])[0]:\n"
                   "            raise ValueError('CRC failure')\n"
                   '        return data[:-4]\n'
                   '\n'
                   '\n'
                   'def make_fragment(job, index):\n'
                   "    data = job['data']\n"
                   "    chunk = 128 if job['kind']=='text' else 1024\n"
                   '    count = max(1, (len(data)+chunk-1)//chunk)\n'
                   "    meta = json.dumps(dict(kind=job['kind'], name=job['name'], size=len(data),\n"
                   '                           '
                   "sha256=hashlib.sha256(data).hexdigest()),separators=(',',':')).encode()\n"
                   '    return '
                   "FRAGMENT.pack(uuid.UUID(job['id']).bytes,index,count,len(meta))+meta+data[index*chunk:(index+1)*chunk], "
                   'count\n'
                   '\n'
                   '\n'
                   'def parse_fragment(body):\n'
                   '    if len(body)<FRAGMENT.size:\n'
                   "        raise ValueError('Truncated fragment')\n"
                   '    ident,index,count,mlen = FRAGMENT.unpack_from(body)\n'
                   '    if not 1<=count<=16384 or index>=count or not 0<mlen<=1024:\n'
                   "        raise ValueError('Invalid fragmentation')\n"
                   '    meta = json.loads(body[FRAGMENT.size:FRAGMENT.size+mlen])\n'
                   "    if meta['kind'] not in ('text','image','audio','file') or not "
                   "0<meta['size']<=16*1024*1024:\n"
                   "        raise ValueError('Invalid transfer metadata')\n"
                   "    chunk = 128 if meta['kind']=='text' else 1024\n"
                   "    if meta['kind']=='text' and meta['size']>65536:\n"
                   "        raise ValueError('Text exceeds original 64 KiB limit')\n"
                   "    if count != (meta['size']+chunk-1)//chunk:\n"
                   "        raise ValueError('Wrong fragment count')\n"
                   '    data=body[FRAGMENT.size+mlen:]\n'
                   "    if len(data)!=min(chunk,meta['size']-index*chunk):\n"
                   "        raise ValueError('Wrong fragment length')\n"
                   '    return str(uuid.UUID(bytes=ident)),index,count,meta,data\n',
       'radio_blocks': 'import os\n'
                       'import queue\n'
                       'import threading\n'
                       'import time\n'
                       'import numpy as np\n'
                       'import pmt\n'
                       'from gnuradio import gr\n'
                       'from .config import load\n'
                       'from .service import Service\n'
                       '\n'
                       '\n'
                       'def airtime(c, raw_length):\n'
                       '    """Estimate a framed RF burst including host delay and turnaround guard."""\n'
                       '    coded=raw_length+4+16*((raw_length+4+238)//239)\n'
                       "    return (2048+12+coded+2570)*16/c['sample_rate']+c['tx_delay_s']+c['tx_guard_s']\n"
                       '\n'
                       '\n'
                       'class MacBridge(gr.sync_block):\n'
                       '    """Raw RX energy observer + PDU socket/MAC service. No stream output."""\n'
                       "    def __init__(self,config_path='configs/node_a.json'):\n"
                       "        gr.sync_block.__init__(self,name='CSMA/CA + app "
                       "bridge',in_sig=[np.complex64],out_sig=None)\n"
                       '        self.c=load(config_path);self.incoming=queue.Queue(maxsize=4096)\n'
                       '        '
                       'self.reading=None;self.read_at=0;self.lock=threading.Lock();self.tx_lock=threading.Lock()\n'
                       '        self.tx_at=0;self.tx_end=0;self.sink=None;self.source=None;self.muted=True\n'
                       '        '
                       "self.message_port_register_in(pmt.intern('rx_in'));self.set_msg_handler(pmt.intern('rx_in'),self.receive)\n"
                       "        self.message_port_register_out(pmt.intern('tx_out'))\n"
                       '        self.service=Service(self.c,self.send,self.incoming,self.sensor)\n'
                       '\n'
                       '    def attach_radio(self,sink,source):\n'
                       '        self.sink=sink;self.source=source\n'
                       '\n'
                       '    def start(self):\n'
                       "        if self.sink is None:raise RuntimeError('Launch with python3 -m sdrchat.hardware; "
                       "radio mute hook is required')\n"
                       '        self.sink.set_attenuation(0,89.75)\n'
                       '        self.service.start();return True\n'
                       '\n'
                       '    def stop(self):\n'
                       '        self.service.stop()\n'
                       '        if self.sink:self.sink.set_attenuation(0,89.75)\n'
                       '        return True\n'
                       '\n'
                       '    def sensor(self):\n'
                       '        now=time.monotonic()\n'
                       '        if not self.muted and now>=self.tx_end:\n'
                       '            self.sink.set_attenuation(0,89.75);self.muted=True\n'
                       '        with self.lock:\n'
                       '            if now-self.read_at>.1:return None\n'
                       '            return self.reading,None\n'
                       '\n'
                       '    def send(self,wire):\n'
                       "        if self.sink is None:raise RuntimeError('Radio sink not attached')\n"
                       "        self.sink.set_attenuation(0,self.c['tx_attenuation_db']);self.muted=False\n"
                       '        duration=airtime(self.c,len(wire))\n'
                       '        self.tx_at=time.monotonic();self.tx_end=self.tx_at+duration\n'
                       '        '
                       "self.message_port_pub(pmt.intern('tx_out'),pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(wire),list(wire))))\n"
                       '        return duration\n'
                       '\n'
                       '    def receive(self,msg):\n'
                       '        # Ignore own RF echo during the estimated transmission/turnaround window.\n'
                       '        if time.monotonic()<self.tx_end:return\n'
                       '        if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):\n'
                       '            try:self.incoming.put_nowait(bytes(pmt.u8vector_elements(pmt.cdr(msg))))\n'
                       '            except queue.Full:pass\n'
                       '\n'
                       '    def work(self,inputs,outputs):\n'
                       '        x=inputs[0]\n'
                       '        if len(x):\n'
                       '            power=10*np.log10(max(float(np.mean(np.abs(x)**2)),1e-20))\n'
                       '            with self.lock:self.reading=power;self.read_at=time.monotonic()\n'
                       '        return len(x)\n',
       'reedsolo_bundled': '#!/usr/bin/env python\n'
                           '# -*- coding: utf-8 -*-\n'
                           '\n'
                           '# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n'
                           '# Copyright (c) 2015 rotorgit\n'
                           '# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n'
                           '\n'
                           "'''\n"
                           'Reed Solomon\n'
                           '============\n'
                           '\n'
                           'A pure-python `universal errors-and-erasures Reed-Solomon Codec '
                           '<http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n'
                           ', based on the wonderful tutorial at\n'
                           '`wikiversity '
                           '<http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\n'
                           'written by "Bobmath" and "LRQ3000".\n'
                           '\n'
                           'The code of wikiversity is here consolidated into a nice API with exceptions '
                           'handling.\n'
                           'The algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\n'
                           'v the number of erasures and nsym = n-k = the number of ECC (error correction code) '
                           'symbols.\n'
                           'This means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n'
                           '(errors where you know the position), and a combination of both errors and erasures.\n'
                           'The code should work on pretty much any reasonable version of python (2.4-3.5),\n'
                           "but I'm only testing on 2.7 - 3.4.\n"
                           '\n'
                           '.. note::\n'
                           '   The codec is universal, meaning that it can decode any message encoded by another '
                           'RS encoder\n'
                           '   as long as you provide the correct parameters.\n'
                           '   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will '
                           'be slower, first because\n'
                           "   we cannot then use the optimized bytearray() structure but only array.array('i', "
                           '...), and also because\n'
                           "   Reed-Solomon's complexity is quadratic (both in encoding and decoding), so this "
                           'means that the longer\n'
                           '   your messages, the longer it will take to encode/decode (quadratically!).\n'
                           '\n'
                           '   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the '
                           'ECC symbols,\n'
                           '   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message '
                           'length and the maximum\n'
                           '   value for one character is constrained by the same mathematical reason). By '
                           'default, we use the field GF(2^8),\n'
                           '   which means that you are limited to values between 0 and 255 (perfect to represent '
                           'a single hexadecimal\n'
                           '   symbol on computers, so you can encode any binary stream) and limited to '
                           'messages+ecc of maximum\n'
                           '   length 255. However, you can "chunk" longer messages to fit them into the message '
                           'length limit.\n'
                           '   The ``RSCodec`` class will automatically apply chunking, by splitting longer '
                           'messages into chunks and\n'
                           "   encode/decode them separately; it shouldn't make a difference from an API "
                           'perspective (ie, from your POV).\n'
                           '\n'
                           '::\n'
                           '\n'
                           '    # Initialization\n'
                           '    >>> from reedsolo import RSCodec\n'
                           '    >>> rsc = RSCodec(10)  # 10 ecc symbols\n'
                           '\n'
                           '    # Encoding\n'
                           '    >>> rsc.encode([1,2,3,4])\n'
                           "    b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M'\n"
                           '    >>> rsc.encode(bytearray([1,2,3,4]))\n'
                           "    bytearray(b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M')\n"
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa'\n"
                           '    # Note that chunking is supported transparently to encode any string length.\n'
                           '\n'
                           '    # Decoding (repairing)\n'
                           "    >>> rsc.decode(b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa')[0]\n"
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 3 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 5 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa')[0]        # 6 "
                           'errors - fail\n'
                           '    Traceback (most recent call last):\n'
                           '      ...\n'
                           '    ReedSolomonError: Could not locate error\n'
                           '\n'
                           '    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 '
                           'erasures)\n'
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2='\n"
                           "    >>> rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')[0]         # 6 "
                           'errors - ok\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=', erase_pos=[3, 4, 5, "
                           '6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n'
                           "    b'hello world'\n"
                           '\n'
                           '    # Checking\n'
                           "    >> rsc.check(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    [False]\n'
                           "    >> rmes, rmesecc = rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    # To use longer chunks or bigger values than 255 (may be very slow)\n'
                           '    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n'
                           '    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n'
                           "    >> mes = 'a' * (4095-12)\n"
                           '    >> mesecc = rsc.encode(mes)\n'
                           '    >> mesecc[2] = 1\n'
                           '    >> mesecc[-1] = 1\n'
                           '    >> rmes, rmesecc = rsc.decode(mesecc)\n'
                           '    >> rsc.check(mesecc)\n'
                           '    [False]\n'
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    If you want full control, you can skip the API and directly use the library as-is. '
                           "Here's how:\n"
                           '\n'
                           '    First you need to init the precomputed tables:\n'
                           '    >> import reedsolo as rs\n'
                           '    >> rs.init_tables(0x11d)\n'
                           '    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please '
                           'check that your prime polynomial is correct for your field.\n'
                           '    Pro tip2: by default, you can only encode messages of max length and max symbol '
                           'value = 256. If you want to encode bigger messages,\n'
                           '    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 '
                           '= max length 2^12 = 4096):\n'
                           '    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n'
                           '    >> rs.init_tables(c_exp=12, prim=prim)\n'
                           '    \n'
                           "    Let's define our RS message and ecc size:\n"
                           '    >> n = 255  # length of total message+ecc\n'
                           '    >> nsym = 12  # length of ecc\n'
                           '    >> mes = "a" * (n-nsym)  # generate a sample message\n'
                           '\n'
                           '    To optimize, you can precompute the generator polynomial:\n'
                           '    >> gen = rs.rs_generator_poly_all(n)\n'
                           '\n'
                           '    Then to encode:\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n'
                           '\n'
                           "    Let's tamper our message:\n"
                           '    >> mesecc[1] = 0\n'
                           '\n'
                           '    To decode:\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n'
                           '    Note that both the message and the ecc are corrected (if possible of course).\n'
                           '    Pro tip: if you know a few erasures positions, you can specify them in a list '
                           '`erase_pos` to double the repair power. But you can also just specify an empty list.\n'
                           '\n'
                           '    If the decoding fails, it will normally automatically check and raise a '
                           'ReedSolomonError exception that you can handle.\n'
                           '    However if you want to manually check if the repaired message is correct, you can '
                           'do so:\n'
                           '    >> rs.rs_check(rmes + recc, nsym)\n'
                           '\n'
                           '    Note: if you want to use multiple reedsolomon with different parameters, you need '
                           'to backup the globals and restore them before calling reedsolo functions:\n'
                           '    >> rs.init_tables()\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n'
                           '    Then at anytime, you can do:\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym)\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n'
                           '    The globals backup is not necessary if you use RSCodec, it will be automatically '
                           'managed.\n'
                           '\n'
                           "    Read the sourcecode's comments for more info about how it works, and for the "
                           'various parameters you can setup if\n'
                           '    you need to interface with other RS codecs.\n'
                           '\n'
                           "'''\n"
                           '\n'
                           '# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials '
                           'inside lists throughout the code and functions (because for now there are a lot of '
                           'list reversing in order to make it work, you never know the order of a polynomial, ie, '
                           'if the first coefficient is the major degree or the constant term...).\n'
                           '\n'
                           'import itertools\n'
                           'import math\n'
                           '\n'
                           '\n'
                           '################### INIT and stuff ###################\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    bytearray\n'
                           '    _bytearray = bytearray\n'
                           'except NameError:  # pragma: no cover\n'
                           '    from array import array\n'
                           '    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n'
                           "        '''Simple bytearray replacement'''\n"
                           '        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '        if isinstance(obj, str):\n'
                           '            obj = [ord(ch) for ch in obj.encode(encoding)]\n'
                           '        elif isinstance(obj, int):\n'
                           '            obj = [0] * obj\n'
                           '        return array("B", obj)\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    # compatibility with Python 2.7\n'
                           '    xrange\n'
                           'except NameError:  # pragma: no cover\n'
                           '    # compatibility with Python 3+\n'
                           '    xrange = range\n'
                           '\n'
                           'class ReedSolomonError(Exception):\n'
                           '    pass\n'
                           '\n'
                           'gf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that '
                           'a simple multiplication of two numbers can be resolved without calling % 255. For more '
                           'infos on how to generate this extended exponentiation table, see paper: "Fast software '
                           'implementation of finite field operations", Cheng Huang and Lihao Xu, Washington '
                           'University in St. Louis, Tech. Rep (2003).\n'
                           'gf_log = _bytearray(256)\n'
                           'field_charac = int(2**8 - 1)\n'
                           '\n'
                           '################### GALOIS FIELD ELEMENTS MATHS ###################\n'
                           '\n'
                           'def rwh_primes1(n):\n'
                           '    # '
                           'http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n'
                           "    ''' Returns  a list of primes < n '''\n"
                           '    sieve = [True] * int(n/2)\n'
                           '    for i in xrange(3,int(n**0.5)+1,2):\n'
                           '        if sieve[int(i/2)]:\n'
                           '            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n'
                           '    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n'
                           '\n'
                           'def find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n'
                           "    '''Compute the list of prime polynomials for the given generator and galois field "
                           "characteristic exponent.'''\n"
                           '    # fast_primes will output less results but will be significantly faster.\n'
                           '    # single will output the first prime polynomial found, so if all you want is to '
                           'just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just '
                           'use that.\n'
                           '\n'
                           '    # A prime polynomial (necessarily irreducible) is necessary to reduce the '
                           'multiplications in the Galois Field, so as to avoid overflows.\n'
                           '    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for '
                           'GF(2^8) for example)? Because we need the values to be unique.\n'
                           '    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), '
                           'then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field '
                           'it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be '
                           'doubled (ie, next power of 2), which will give 256. Then we must reduce, because we '
                           'have overflowed above the maximum value of 255. But, if we modulo 255, this will '
                           'generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. '
                           "This is very bad, as it's then not anymore a bijection (ie, a non-zero value doesn't "
                           "have a unique index). That's why we can't just modulo 255, but we need another number "
                           'above 255, which is called the prime polynomial.\n'
                           '    # Why so much hassle? Because we are using precomputed look-up tables for '
                           'multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and '
                           'alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our '
                           'result. But just like in our original field we had 0,1,2,...,p-1 distinct unique '
                           'values, in our "LUT" field using alpha we must have unique distinct values (we don\'t '
                           'care that they are different from the original field as long as they are unique and '
                           "distinct). That's why we need to avoid duplicated values, and to avoid duplicated "
                           'values we need to use a prime irreducible polynomial.\n'
                           '\n'
                           '    # Here is implemented a bruteforce approach to find all these prime polynomials, '
                           'by generating every possible prime polynomials (ie, every integers between '
                           'field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we '
                           'reject the candidate prime polynomial if it duplicates even one value or if it '
                           'generates a value above field_charac (ie, cause an overflow).\n'
                           '    # Note that this algorithm is slow if the field is too big (above 12), because '
                           "it's an exhaustive search algorithm. There are probabilistic approaches, and almost "
                           'surely prime approaches, but there is no determistic polynomial time algorithm to find '
                           'irreducible monic polynomials. More info can be found at: '
                           'http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n'
                           '    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. '
                           'Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the '
                           'eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n'
                           '\n'
                           '    # Prepare the finite field characteristic (2^p - 1), this also represent the '
                           'maximum possible value in this field\n'
                           "    root_charac = 2 # we're in GF(2)\n"
                           '    field_charac = int(root_charac**c_exp - 1)\n'
                           '    field_charac_next = int(root_charac**(c_exp+1) - 1)\n'
                           '\n'
                           '    prim_candidates = []\n'
                           '    if fast_primes:\n'
                           '        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime '
                           'polynomials and check later if they really are irreducible\n'
                           '        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter '
                           'out too small primes\n'
                           '    else:\n'
                           '        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try '
                           'each possible prime polynomial, but skip even numbers (because divisible by 2 so '
                           'necessarily not irreducible)\n'
                           '\n'
                           '    # Start of the main loop\n'
                           '    correct_primes = []\n'
                           '    for prim in prim_candidates: # try potential candidates primitive irreducible '
                           'polys\n'
                           '        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was '
                           'already generated in the field (value at index x is set to 1) or not (set to 0 by '
                           'default)\n'
                           '        conflict = False # flag to know if there was at least one conflict\n'
                           '\n'
                           '        # Second loop, build the whole Galois Field\n'
                           '        x = 1\n'
                           '        for i in xrange(field_charac):\n'
                           '            # Compute the next value in the field (ie, the next power of '
                           'alpha/generator)\n'
                           '            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '            # Rejection criterion: if the value overflowed (above field_charac) or is '
                           'a duplicate of a previously generated power of alpha, then we reject this polynomial '
                           '(not prime)\n'
                           '            if x > field_charac or seen[x] == 1:\n'
                           '                conflict = True\n'
                           '                break\n'
                           '            # Else we flag this value as seen (to maybe detect future duplicates), and '
                           'we continue onto the next power of alpha\n'
                           '            else:\n'
                           '                seen[x] = 1\n'
                           '\n'
                           "        # End of the second loop: if there's no conflict (no overflow nor duplicated "
                           'value), this is a prime polynomial!\n'
                           '        if not conflict: \n'
                           '            correct_primes.append(prim)\n'
                           '            if single: return prim\n'
                           '\n'
                           '    # Return the list of all prime polynomials\n'
                           '    return correct_primes # you can use the following to print the hexadecimal '
                           'representation of each prime polynomial: print [hex(i) for i in correct_primes]\n'
                           '\n'
                           'def init_tables(prim=0x11d, generator=2, c_exp=8):\n'
                           "    '''Precompute the logarithm and anti-log tables for faster computation later, "
                           'using the provided primitive polynomial.\n'
                           '    These tables are used for multiplication/division since addition/substraction are '
                           'simple XOR operations inside GF of characteristic 2.\n'
                           '    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any '
                           'number b (the base or generator of the logarithm), then we can use any number b to '
                           'precompute logarithm and anti-log (exponentiation) tables to use for multiplying two '
                           'numbers x and y.\n'
                           "    That's why when we use a different base/generator number, the log and anti-log "
                           'tables are drastically different, but the resulting computations are the same given '
                           'any such tables.\n'
                           '    For more infos, see '
                           'https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n'
                           "    '''\n"
                           '    # generator is the generator number (the "increment" that will be used to walk '
                           'through the field by multiplication, this must be a prime number). This is basically '
                           'the base of the logarithm/anti-log tables. Also often noted "alpha" in academic '
                           'books.\n'
                           '    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it '
                           "can't represented as the product of two smaller polynomials). It's a polynomial in the "
                           "binary sense: each bit is a coefficient, but in fact it's an integer between "
                           'field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial '
                           'will be used to reduce the overflows back into the range of the Galois Field without '
                           'duplicating values (all values should be unique). See the function find_prime_polys() '
                           'and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n'
                           "    # note that the choice of generator or prime polynomial doesn't matter very much: "
                           'any two finite fields of size p^n have identical structure, even if they give the '
                           'individual elements different names (ie, the coefficients of the codeword will be '
                           'different, but the final result will be the same: you can always correct as many '
                           "errors/erasures with any choice for those parameters). That's why it makes sense to "
                           'refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as '
                           'one concept: GF(p^n). It can however impact sensibly the speed (because some '
                           'parameters will generate sparser tables).\n'
                           "    # c_exp is the exponent for the field's characteristic GF(2^c_exp)\n"
                           '\n'
                           '    # Redefine _bytearray() in case we need to support integers or messages of length '
                           '> 256\n'
                           '    global _bytearray\n'
                           '    if c_exp <= 8:\n'
                           '        _bytearray = bytearray\n'
                           '    else:\n'
                           '        from array import array\n'
                           '        def _bytearray(obj = 0, encoding = "latin-1"):\n'
                           "            '''Fake bytearray replacement, supporting int values above 255'''\n"
                           '            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '            if isinstance(obj, str):  # obj is a string, convert to list of ints\n'
                           '                obj = obj.encode(encoding)\n'
                           '                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n'
                           '                    obj = [ord(chr) for chr in obj]\n'
                           '                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need '
                           "to convert to int for array.array('i', obj)\n"
                           '                    obj = [int(chr) for chr in obj]\n'
                           '                else:\n'
                           '                    raise(ValueError, "Type of object not recognized!")\n'
                           '            elif isinstance(obj, int):  # compatibility with list preallocation '
                           'bytearray(int)\n'
                           '                obj = [0] * obj\n'
                           '            elif isinstance(obj, bytes):\n'
                           '                obj = [int(b) for b in obj]\n'
                           "            # Else obj is a list of int, it's ok\n"
                           '            return array("i", obj)\n'
                           '\n'
                           '    # Init global tables\n'
                           '    global gf_exp, gf_log, field_charac\n'
                           '    field_charac = int(2**c_exp - 1)\n'
                           '    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first '
                           'two elements will always be [GF256int(1), generator]\n'
                           '    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus '
                           'unused\n'
                           '\n'
                           '    # For each possible value in the galois field 2^8, we will pre-compute the '
                           'logarithm and anti-logarithm (exponential) of this value\n'
                           '    # To do that, we generate the Galois Field F(2^p) by building a list starting with '
                           'the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, '
                           'α^2, ..., α^(p-1).\n'
                           '    x = 1\n'
                           '    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 '
                           'because of modulo: g^255==g^0 but either way, this does not change the later outputs '
                           '(ie, the ecc symbols will be the same either way)\n'
                           '        gf_exp[i] = x # compute anti-log for this value and store it in a table\n'
                           '        gf_log[x] = i # compute log at the same time\n'
                           '        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '        # If you use only generator==2 or a power of 2, you can use the following '
                           'which is faster than gf_mult_noLUT():\n'
                           '        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power '
                           'of 2^y)\n'
                           '        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n'
                           '            #x ^= prim # substract the primary polynomial to the current value '
                           '(instead of 255, so that we get a unique set made of coprime numbers), this is the '
                           'core of the tables generation\n'
                           '\n'
                           "    # Optimization: double the size of the anti-log table so that we don't need to mod "
                           '255 to stay inside the bounds (because we will mainly use this table for the '
                           'multiplication of two GF numbers, no more).\n'
                           '    for i in xrange(field_charac, field_charac * 2):\n'
                           '        gf_exp[i] = gf_exp[i - field_charac]\n'
                           '\n'
                           '    return [gf_log, gf_exp, field_charac]\n'
                           '\n'
                           'def gf_add(x, y):\n'
                           '    return x ^ y\n'
                           '\n'
                           'def gf_sub(x, y):\n'
                           '    return x ^ y # in binary galois field, substraction is just the same as addition '
                           '(since we mod 2)\n'
                           '\n'
                           'def gf_neg(x):\n'
                           '    return x\n'
                           '\n'
                           'def gf_inverse(x):\n'
                           '    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n'
                           '\n'
                           'def gf_mul(x, y):\n'
                           '    if x == 0 or y == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_div(x, y):\n'
                           '    if y == 0:\n'
                           '        raise ZeroDivisionError()\n'
                           '    if x == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_pow(x, power):\n'
                           '    return gf_exp[(gf_log[x] * power) % field_charac]\n'
                           '\n'
                           'def gf_mult_noLUT_slow(x, y, prim=0):\n'
                           "    '''Multiplication in Galois Fields without using a precomputed look-up table (and "
                           "thus it's slower) by using the standard carry-less multiplication + modular reduction "
                           "using an irreducible prime polynomial.'''\n"
                           '\n'
                           '    ### Define bitwise carry-less operations as inner functions ###\n'
                           '    def cl_mult(x,y):\n'
                           "        '''Bitwise carry-less multiplication on integers'''\n"
                           '        z = 0\n'
                           '        i = 0\n'
                           '        while (y>>i) > 0:\n'
                           '            if y & (1<<i):\n'
                           '                z ^= x<<i\n'
                           '            i += 1\n'
                           '        return z\n'
                           '\n'
                           '    def bit_length(n):\n'
                           "        '''Compute the position of the most significant bit (1) of an integer. "
                           "Equivalent to int.bit_length()'''\n"
                           '        bits = 0\n'
                           '        while n >> bits: bits += 1\n'
                           '        return bits\n'
                           ' \n'
                           '    def cl_div(dividend, divisor=None):\n'
                           "        '''Bitwise carry-less long division on integers and returns the remainder'''\n"
                           '        # Compute the position of the most significant bit for each integers\n'
                           '        dl1 = bit_length(dividend)\n'
                           '        dl2 = bit_length(divisor)\n'
                           '        # If the dividend is smaller than the divisor, just exit\n'
                           '        if dl1 < dl2:\n'
                           '            return dividend\n'
                           '        # Else, align the most significant 1 of the divisor to the most significant 1 '
                           'of the dividend (by shifting the divisor)\n'
                           '        for i in xrange(dl1-dl2,-1,-1):\n'
                           '            # Check that the dividend is divisible (useless for the first iteration '
                           'but important for the next ones)\n'
                           '            if dividend & (1 << i+dl2-1):\n'
                           '                # If divisible, then shift the divisor to align the most significant '
                           'bits and XOR (carry-less substraction)\n'
                           '                dividend ^= divisor << i\n'
                           '        return dividend\n'
                           ' \n'
                           '    ### Main GF multiplication routine ###\n'
                           ' \n'
                           '    # Multiply the gf numbers\n'
                           '    result = cl_mult(x,y)\n'
                           '    # Then do a modular reduction (ie, remainder from the division) with an '
                           'irreducible primitive polynomial so that it stays inside GF bounds\n'
                           '    if prim > 0:\n'
                           '        result = cl_div(result, prim)\n'
                           ' \n'
                           '    return result\n'
                           '\n'
                           'def gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n'
                           "    '''Galois Field integer multiplication using Russian Peasant Multiplication "
                           'algorithm (faster than the standard multiplication + modular reduction).\n'
                           '    If prim is 0 and carryless=False, then the function produces the result for a '
                           'standard integers multiplication (no carry-less arithmetics nor modular '
                           "reduction).'''\n"
                           '    r = 0\n'
                           '    while y: # while y is above 0\n'
                           '        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the '
                           "corresponding x to r (the sum of all x's corresponding to odd y's will give the final "
                           "product). Note that since we're in GF(2), the addition is in fact an XOR (very "
                           'important because in GF(2) the multiplication and additions are carry-less, thus it '
                           'changes the result!).\n'
                           '        y = y >> 1 # equivalent to y // 2\n'
                           '        x = x << 1 # equivalent to x*2\n'
                           '        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 '
                           'then apply modular reduction using the primitive polynomial (we just substract, but '
                           'since the primitive number can be above 256 then we directly XOR).\n'
                           '\n'
                           '    return r\n'
                           '\n'
                           '\n'
                           '################### GALOIS FIELD POLYNOMIALS MATHS ###################\n'
                           '\n'
                           'def gf_poly_scale(p, x):\n'
                           '    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n'
                           '\n'
                           'def gf_poly_add(p, q):\n'
                           '    r = _bytearray( max(len(p), len(q)) )\n'
                           '    r[len(r)-len(p):len(r)] = p\n'
                           '    #for i in xrange(len(p)):\n'
                           '        #r[i + len(r) - len(p)] = p[i]\n'
                           '    for i in xrange(len(q)):\n'
                           '        r[i + len(r) - len(q)] ^= q[i]\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul(p, q):\n'
                           "    '''Multiply two polynomials, inside Galois Field (but the procedure is generic). "
                           "Optimized function by precomputation of log.'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Precompute the logarithm of p\n'
                           '    lp = [gf_log[p[i]] for i in xrange(len(p))]\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        qj = q[j] # optimization: load the coefficient once\n'
                           '        if qj != 0: # log(0) is undefined, we need to check that\n'
                           '            lq = gf_log[qj] # Optimization: precache the logarithm of the current '
                           'coefficient of q\n'
                           '            for i in xrange(len(p)):\n'
                           '                if p[i] != 0: # log(0) is undefined, need to check that...\n'
                           '                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = '
                           'gf_add(r[i+j], gf_mul(p[i], q[j]))\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials '
                           "without precomputation, but thus it's slower\n"
                           "    '''Multiply two polynomials, inside Galois Field'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        for i in xrange(len(p)):\n'
                           '            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], '
                           "gf_mul(p[i], q[j])) -- you can see it's your usual polynomial multiplication\n"
                           '    return r\n'
                           '\n'
                           'def gf_poly_neg(poly):\n'
                           "    '''Returns the polynomial with all coefficients negated. In GF(2^p), negation does "
                           "not change the coefficient, so we return the polynomial as-is.'''\n"
                           '    return poly\n'
                           '\n'
                           'def gf_poly_div(dividend, divisor):\n'
                           "    '''Fast polynomial division by using Extended Synthetic Division and optimized for "
                           "GF(2^p) computations (doesn't work with standard polynomials outside of this galois "
                           "field).'''\n"
                           '    # CAUTION: this function expects polynomials to follow the opposite convention at '
                           'decoding: the terms must go from the biggest to lowest degree (while most other '
                           'functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, '
                           '2, 1], NOT [1, 2, 5]\n'
                           '\n'
                           '    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the '
                           'ecc bytes will be computed\n'
                           '    #normalizer = divisor[0] # precomputing for performance\n'
                           '    for i in xrange(len(dividend) - (len(divisor)-1)):\n'
                           '        #msg_out[i] /= normalizer # for general polynomial division (when polynomials '
                           'are non-monic), the usual way of using synthetic division is to divide the divisor '
                           'g(x) with its leading coefficient (call it a). In this implementation, this means:we '
                           'need to compute: coef = msg_out[i] / gen[0]. For more infos, see '
                           'http://en.wikipedia.org/wiki/Synthetic_division\n'
                           '        coef = msg_out[i] # precaching\n'
                           '        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly '
                           "(and it's also a good optimization). In fact if you remove it, it should still work "
                           "because gf_mul() will take care of the condition. But it's still a good practice to "
                           'put the condition here.\n'
                           '            for j in xrange(1, len(divisor)): # in synthetic division, we always skip '
                           "the first coefficient of the divisior, because it's only used to normalize the "
                           'dividend coefficient\n'
                           '                if divisor[j] != 0: # log(0) is undefined\n'
                           '                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the '
                           'more mathematically correct (but xoring directly is faster): msg_out[i + j] += '
                           '-divisor[j] * coef\n'
                           '\n'
                           '    # The resulting msg_out contains both the quotient and the remainder, the '
                           'remainder being the size of the divisor (the remainder has necessarily the same degree '
                           "as the divisor -- not length but degree == length-1 -- since it's what we couldn't "
                           'divide from the dividend), so we compute the index where this separation is, and '
                           'return the quotient and remainder.\n'
                           '    separator = -(len(divisor)-1)\n'
                           '    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n'
                           '\n'
                           'def gf_poly_square(poly):  # pragma: no cover\n'
                           "    '''Linear time implementation of polynomial squaring. For details, see paper: "
                           '"A fast software implementation for arithmetic operations in GF (2n)". De Win, E., '
                           'Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In '
                           "Advances in Cryptology - Asiacrypt'96 (pp. 65-76). Springer Berlin Heidelberg.'''\n"
                           '    length = len(poly)\n'
                           '    out = _bytearray(2*length - 1)\n'
                           '    for i in xrange(length-1):\n'
                           '        p = poly[i]\n'
                           '        k = 2*i\n'
                           '        if p != 0:\n'
                           '            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo '
                           '(2^r)-1 since gf_exp is duplicated up to 510.\n'
                           '            out[k] = gf_exp[2*gf_log[p]]\n'
                           '        #else: # not necessary since the output is already initialized to an array of '
                           '0\n'
                           '            #out[k] = 0\n'
                           '    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n'
                           '    if out[0] == 0: out[0] = 2*poly[1] - 1\n'
                           '    return out\n'
                           '\n'
                           'def gf_poly_eval(poly, x):\n'
                           "    '''Evaluates a polynomial in GF(2^p) given the value for x. This is based on "
                           "Horner's scheme for maximum efficiency.'''\n"
                           '    y = poly[0]\n'
                           '    for i in xrange(1, len(poly)):\n'
                           '        y = gf_mul(y, x) ^ poly[i]\n'
                           '    return y\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON ENCODING ###################\n'
                           '\n'
                           'def rs_generator_poly(nsym, fcr=0, generator=2):\n'
                           "    '''Generate an irreducible generator polynomial (necessary to encode a message "
                           "into Reed-Solomon)'''\n"
                           '    g = _bytearray([1])\n'
                           '    for i in xrange(nsym):\n'
                           '        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n'
                           '    return g\n'
                           '\n'
                           'def rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n'
                           "    '''Generate all irreducible generator polynomials up to max_nsym (usually you can "
                           'use n, the length of the message+ecc). Very useful to reduce processing time if you '
                           "want to encode using variable schemes and nsym rates.'''\n"
                           '    g_all = {}\n'
                           '    g_all[0] = g_all[1] = _bytearray([1])\n'
                           '    for nsym in xrange(max_nsym):\n'
                           '        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n'
                           '    return g_all\n'
                           '\n'
                           'def rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Simple Reed-Solomon encoding (mainly an example for you to understand how it "
                           "works, because it's slower than the inlined function below)'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    # Pad the message, then divide it by the irreducible generator polynomial\n'
                           '    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n'
                           '    # The remainder is our RS code! Just append it to our original message to get our '
                           'full codeword (this represents a polynomial of max 256 terms)\n'
                           '    msg_out = msg_in + remainder\n'
                           '    # Return the codeword\n'
                           '    return msg_out\n'
                           '\n'
                           'def rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Reed-Solomon main encoding function, using polynomial division (Extended "
                           'Synthetic Division, the fastest algorithm available to my knowledge), better explained '
                           "at http://research.swtch.com/field'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    msg_in = _bytearray(msg_in)\n'
                           '    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the '
                           'values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc '
                           'symbols).\n'
                           '\n'
                           '    # Precompute the logarithm of every items in the generator\n'
                           '    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n'
                           '\n'
                           '    # Extended synthetic division main loop\n'
                           '    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is '
                           'about 2x faster)\n'
                           '    for i in xrange(len(msg_in)):\n'
                           "        coef = msg_out[i] # Note that it's msg_out here, not msg_in. Thus, we reuse "
                           'the updated value at each iteration (this is how Synthetic Division works: instead of '
                           'storing in a temporary register the intermediate values, we directly commit them to '
                           'the output).\n'
                           '        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial '
                           'division (when polynomials are non-monic), the usual way of using synthetic division '
                           'is to divide the divisor g(x) with its leading coefficient (call it a). In this '
                           'implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n'
                           '        if coef != 0: # log(0) is undefined, so we need to manually check for this '
                           "case. There's no need to check the divisor here because we know it can't be 0 since we "
                           'generated it.\n'
                           '            lcoef = gf_log[coef] # precaching\n'
                           '\n'
                           '            for j in xrange(1, len(gen)): # in synthetic division, we always skip the '
                           "first coefficient of the divisior, because it's only used to normalize the dividend "
                           'coefficient (which is here useless since the divisor, the generator polynomial, is '
                           'always monic)\n'
                           '                #if gen[j] != 0: # log(0) is undefined so we need to check that, but '
                           "it slow things down in fact and it's useless in our case (reed-solomon encoding) since "
                           'we know that all coefficients in the generator are not 0\n'
                           '                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent '
                           'to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we '
                           "are in GF256, it's equivalent to an addition and to an XOR). In other words, this is "
                           'simply a "multiply-accumulate operation"\n'
                           '\n'
                           '    # Recopy the original message bytes (overwrites the part where the quotient was '
                           'computed)\n'
                           '    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is '
                           'msg_in padded with [0]*nsym\n'
                           '    return msg_out\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON DECODING ###################\n'
                           '\n'
                           'def rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Given the received codeword msg and the number of error correcting symbols "
                           '(nsym), computes the syndromes polynomial.\n'
                           "    Mathematically, it's essentially equivalent to a Fourrier Transform (Chien search "
                           'being the inverse).\n'
                           "    '''\n"
                           '    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). '
                           'This effectively shifts the syndrome, and will shift every computations depending on '
                           'the syndromes (such as the errors locator polynomial, errors evaluator polynomial, '
                           'etc. but not the errors positions).\n'
                           '    # This is not necessary as anyway syndromes are defined such as there are only '
                           'non-zero coefficients (the only 0 is the shift of the constant here) and subsequent '
                           'computations will/must account for the shift by skipping the first iteration (eg, the '
                           'often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt '
                           'every subsequent computations to start from 0 instead of 1.\n'
                           '    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n'
                           '\n'
                           'def rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list '
                           'of the positions of the errors/erasures/errata\n'
                           "    '''Forney algorithm, computes the values (error magnitude) to correct the input "
                           "message.'''\n"
                           '    global field_charac\n'
                           '    msg = _bytearray(msg_in)\n'
                           '    # calculate errata locator polynomial to correct both errors and erasures (by '
                           'combining the errors positions given by the error locator polynomial found by BM with '
                           'the erasures positions given by caller)\n'
                           '    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to '
                           'coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it '
                           'will become [len(msg)-1, len(msg)-2, len(msg) -3])\n'
                           '    err_loc = rs_find_errata_locator(coef_pos, generator)\n'
                           '    # calculate errata evaluator polynomial (often called Omega or Gamma in academic '
                           'papers)\n'
                           '    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n'
                           '\n'
                           '    # Second part of Chien search to get the error location polynomial X from the '
                           'error positions in err_pos (the roots of the error locator polynomial, ie, where it '
                           'evaluates to 0)\n'
                           '    X = [] # will store the position of the errors\n'
                           '    for i in xrange(len(coef_pos)):\n'
                           '        l = field_charac - coef_pos[i]\n'
                           '        X.append( gf_pow(generator, -l) )\n'
                           '\n'
                           '    # Forney algorithm: compute the magnitudes\n'
                           '    E = _bytearray(len(msg)) # will store the values that need to be corrected '
                           '(substracted) to the message containing errors. This is sometimes called the error '
                           'magnitude polynomial.\n'
                           '    Xlength = len(X)\n'
                           '    for i, Xi in enumerate(X):\n'
                           '\n'
                           '        Xi_inv = gf_inverse(Xi)\n'
                           '\n'
                           '        # Compute the formal derivative of the error locator polynomial (see Blahut, '
                           'Algebraic codes for data transmission, pp 196-197).\n'
                           '        # the formal derivative of the errata locator is used as the denominator of '
                           'the Forney Algorithm, which simply says that the ith error value is given by '
                           'error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See '
                           'Blahut, Algebraic codes for data transmission, pp 196-197.\n'
                           '        err_loc_prime_tmp = []\n'
                           '        for j in xrange(Xlength):\n'
                           '            if j != i:\n'
                           '                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n'
                           '        # compute the product, which is the denominator of the Forney algorithm '
                           '(errata locator derivative)\n'
                           '        err_loc_prime = 1\n'
                           '        for coef in err_loc_prime_tmp:\n'
                           '            err_loc_prime = gf_mul(err_loc_prime, coef)\n'
                           '        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, '
                           '1)\n'
                           '\n'
                           '        # Test if we could find the errata locator, else we raise an Exception '
                           '(because else since we divide y by err_loc_prime to compute the magnitude, we will get '
                           'a ZeroDivisionError exception otherwise)\n'
                           '        if err_loc_prime == 0:\n'
                           '            raise ReedSolomonError("Decoding failed: Forney algorithm could not '
                           'properly detect where the errors are located (errata locator prime is 0).")\n'
                           '\n'
                           '        # Compute y (evaluation of the errata evaluator polynomial)\n'
                           '        # This is a more faithful translation of the theoretical equation contrary to '
                           'the old forney method. Here it is exactly copy/pasted from the included presentation '
                           'decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) '
                           "(in the paper it's for j in s, but it's useless when len(X) < s because we compute "
                           'neutral terms 1 for nothing, and wrong when correcting more than s erasures or '
                           'erasures+errors since it prevents computing all required terms).\n'
                           '        # Thus here this method works with erasures too because firstly we fixed the '
                           "equation to be like the theoretical one (don't know why it was modified in "
                           "_old_forney(), if it's an optimization, it doesn't enhance anything), and secondly "
                           'because we removed the product bound on s, which prevented computing errors and '
                           'erasures above the s=(n-k)//2 bound.\n'
                           '        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm '
                           '(errata evaluator evaluated)\n'
                           '        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n'
                           '        \n'
                           '        # Compute the magnitude\n'
                           '        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, '
                           'calculated by the Forney algorithm (an equation in fact): dividing the errata '
                           'evaluator with the errata locator derivative gives us the errata magnitude (ie, value '
                           'to repair) the ith symbol\n'
                           '        E[err_pos[i]] = magnitude # store the magnitude for this error into the '
                           'magnitude polynomial\n'
                           '\n'
                           '    # Apply the correction of values to get our message corrected! (note that the ecc '
                           'bytes also gets corrected!)\n'
                           "    # (this isn't the Forney algorithm, we just apply the result of decoding here)\n"
                           '    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct '
                           'message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is '
                           "replaced by XOR since it's equivalent in GF(2^p)). So in fact here we substract from "
                           'the received message the errors magnitude, which logically corrects the value to what '
                           'it should be.\n'
                           '    return msg\n'
                           '\n'
                           'def rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n'
                           "    '''Find error/errata locator and evaluator polynomials with Berlekamp-Massey "
                           "algorithm'''\n"
                           '    # The idea is that BM will iteratively estimate the error locator polynomial.\n'
                           '    # To do this, it will compute a Discrepancy term called Delta, which will tell us '
                           'if the error locator polynomial needs an update or not\n'
                           "    # (hence why it's called discrepancy: it tells us when we are getting off board "
                           'from the correct value).\n'
                           '\n'
                           '    # Init the polynomials\n'
                           '    if erase_loc: # if the erasure locator polynomial is supplied, we init with its '
                           'value, so that we include erasures in the final locator polynomial\n'
                           '        err_loc = _bytearray(erase_loc)\n'
                           '        old_loc = _bytearray(erase_loc)\n'
                           '    else:\n'
                           '        err_loc = _bytearray([1]) # This is the main variable we want to fill, also '
                           'called Sigma in other notations or more formally the errors/errata locator '
                           'polynomial.\n'
                           '        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the '
                           'errata locator polynomial of the previous iteration in order to update other necessary '
                           'variables.\n'
                           '    #L = 0 # update flag variable, not needed here because we use an alternative '
                           'equivalent way of checking if update is needed (but using the flag could potentially '
                           'be faster depending on if using length(list) is taking linear time in your language, '
                           "here in Python it's constant so it's as fast.\n"
                           '\n'
                           '    # Fix the syndrome shifting: when computing the syndrome, some implementations may '
                           'prepend a 0 coefficient for the lowest degree term (the constant). This is a case of '
                           'syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I '
                           "don't know what purpose serves this shifting). If that's the case, then we need to "
                           'account for the syndrome shifting when we use the syndrome such as inside BM, by '
                           'skipping those prepended coefficients.\n'
                           '    # Another way to detect the shifting is to detect the 0 coefficients: by '
                           'definition, a syndrome does not contain any 0 coefficient (except if there are no '
                           "errors/erasures, in this case they are all 0). This however doesn't work with the "
                           'modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, '
                           'leaving only the coefficients corresponding to errors.\n'
                           '    synd_shift = 0\n'
                           '    if len(synd) > nsym: synd_shift = len(synd) - nsym\n'
                           '\n'
                           '    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), '
                           'except when you input a partial erase_loc and using the full syndrome instead of the '
                           'Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail '
                           'badly with IndexError).\n'
                           '        if erase_loc: # if an erasures locator polynomial was provided to init the '
                           'errors locator polynomial, then we must skip the FIRST erase_count iterations (not the '
                           'last iterations, this is very important!)\n'
                           '            K = erase_count+i+synd_shift\n'
                           "        else: # if erasures locator is not provided, then either there's no erasures "
                           "to account or we use the Forney syndromes, so we don't need to use erase_count nor "
                           'erase_loc (the erasures have been trimmed out of the Forney syndromes).\n'
                           '            K = i+synd_shift\n'
                           '\n'
                           '        # Compute the discrepancy Delta\n'
                           '        # Here is the close-to-the-books operation to compute the discrepancy Delta: '
                           "it's a simple polynomial multiplication of error locator with the syndromes, and then "
                           'we get the Kth element.\n'
                           '        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be '
                           "gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it's not "
                           'absolutely necessary to correctly decode.\n'
                           "        # But this can be optimized: since we only need the Kth element, we don't need "
                           'to compute the polynomial multiplication for any other element but the Kth. Thus to '
                           'optimize, we compute the polymul only at the item we need, skipping the rest (avoiding '
                           'a nested loop, thus we are linear time instead of quadratic).\n'
                           '        # This optimization is actually described in several figures of the book '
                           '"Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge '
                           'university press.\n'
                           '        delta = synd[K]\n'
                           '        for j in xrange(1, len(err_loc)):\n'
                           '            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called '
                           'discrepancy. Here we do a partial polynomial multiplication (ie, we compute the '
                           'polynomial multiplication only for the term of degree K). Should be equivalent to '
                           'brownanrs.polynomial.mul_at().\n'
                           '        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n'
                           '\n'
                           '        # Shift polynomials to compute the next degree\n'
                           '        old_loc = old_loc + _bytearray([0])\n'
                           '\n'
                           '        # Iteratively estimate the errata locator and evaluator polynomials\n'
                           "        if delta != 0: # Update only if there's a discrepancy\n"
                           '            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined '
                           'because rule A just says that we skip any modification for this iteration)\n'
                           '            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as '
                           'long as L is correctly computed\n'
                           '                # Computing errata locator polynomial Sigma\n'
                           '                new_loc = gf_poly_scale(old_loc, delta)\n'
                           '                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we '
                           'are doing err_loc * 1/delta = err_loc // delta\n'
                           '                err_loc = new_loc\n'
                           '                # Update the update flag\n'
                           "                #L = K - L # the update flag L is tricky: in Blahut's schema, it's "
                           'mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this '
                           'function, if you forgot to do `- erase_count` it would lead to correcting only '
                           '2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this '
                           'latest draft, this will lead to a wrong decoding in some cases where it should '
                           'correctly decode! Thus you should try with and without `- erase_count` to update L on '
                           'your own implementation and see which one works OK without producing wrong decoding '
                           'failures.\n'
                           '\n'
                           '            # Update with the discrepancy\n'
                           '            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n'
                           '\n'
                           "    # Check if the result is correct, that there's not too many errors to correct\n"
                           '    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, '
                           'else errs will not be of the correct size\n'
                           '    errs = len(err_loc) - 1\n'
                           '    if (errs-erase_count) * 2 + erase_count > nsym:\n'
                           '        raise ReedSolomonError("Too many errors to correct")\n'
                           '\n'
                           '    return err_loc\n'
                           '\n'
                           'def rs_find_errata_locator(e_pos, generator=2):\n'
                           "    '''Compute the erasures/errors/errata locator polynomial from the "
                           'erasures/errors/errata positions (the positions must be relative to the x coefficient, '
                           'eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being '
                           'the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients '
                           'are reversed since the ecc characters are placed as the first coefficients of the '
                           'polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] '
                           "= erasures_loc to be specified as an argument.'''\n"
                           '    # See: '
                           'http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf '
                           'and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of '
                           'Research and development 23.3 (1979): 299-315. '
                           'http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and '
                           'also a MatLab implementation here: '
                           'http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n'
                           '    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the '
                           'multiplication starts correctly without nulling any term\n'
                           '    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for '
                           'i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in '
                           "this library it's gf(3)). To generate c*x where c is a constant, we simply generate a "
                           'Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient '
                           'for x^1.\n'
                           '    for i in e_pos:\n'
                           '        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, '
                           'i), 0]) )\n'
                           '    return e_loc\n'
                           '\n'
                           'def rs_find_error_evaluator(synd, err_loc, nsym):\n'
                           "    '''Compute the error (or erasures if you supply sigma=erasures locator polynomial, "
                           'or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata '
                           'locator Sigma. Omega is already computed at the same time as Sigma inside the '
                           'Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute '
                           'Omega afterwards using this method, or just ensure that Omega computed by BM is '
                           "correct given Sigma.'''\n"
                           '    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n'
                           '    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # '
                           'first multiply syndromes * errata_locator, then do a polynomial division to truncate '
                           'the polynomial to the required length\n'
                           '\n'
                           '    # Faster way that is equivalent\n'
                           '    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the '
                           'errata locator polynomial\n'
                           '    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of '
                           'the length we want, which is equivalent to slicing the list (which represents the '
                           'polynomial)\n'
                           '\n'
                           '    return remainder\n'
                           '\n'
                           'def rs_find_errors(err_loc, nmess, generator=2):\n'
                           "    '''Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce "
                           "trial, this is a sort of Chien's search (but less efficient, Chien's search is a way "
                           "to evaluate the polynomial such that each evaluation only takes constant time).'''\n"
                           '    # nmess = length of whole codeword (message + ecc symbols)\n'
                           '    errs = len(err_loc) - 1\n'
                           '    err_pos = []\n'
                           '    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here '
                           'we optimize to just check the interesting symbols\n'
                           "        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It's a 0? Bingo, it's a "
                           'root of the error locator polynomial, in other terms this is the location of an error\n'
                           '            err_pos.append(nmess - 1 - i)\n'
                           '    # Sanity check: the number of errors/errata positions found should be exactly the '
                           'same as the length of the errata locator polynomial\n'
                           '    if len(err_pos) != errs:\n'
                           '        # TODO: to decode messages+ecc with length n > 255, we may try to use a '
                           'bruteforce approach: the correct positions ARE in the final array j, but the problem '
                           "is because we are above the Galois Field's range, there is a wraparound so that for "
                           'example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because '
                           "258 % 255 == 3, same for the other values), so we can't discriminate. The issue is "
                           'that fixing any errs_nb errors among those will always give a correct output message '
                           '(in the sense that the syndrome will be all 0), so we may not even be able to check if '
                           "that's correct or not, so I'm not sure the bruteforce approach may even be possible.\n"
                           '        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the '
                           'errata locator polynomial!")\n'
                           '    return err_pos\n'
                           '\n'
                           'def rs_forney_syndromes(synd, pos, nmess, generator=2):\n'
                           '    # Compute Forney syndromes, which computes a modified syndromes to compute only '
                           'errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which '
                           'allows to correct the message based on the location of errors.\n'
                           '    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree '
                           'positions (instead of the erasures positions)\n'
                           '\n'
                           '    # Optimized method, all operations are inlined\n'
                           '    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is '
                           'always 0 by definition\n'
                           '    for i in xrange(len(pos)):\n'
                           '        x = gf_pow(generator, erase_pos_reversed[i])\n'
                           '        for j in xrange(len(fsynd) - 1):\n'
                           '            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n'
                           "        #fsynd.pop() # useless? it doesn't change the results of computations to leave "
                           'it there\n'
                           '\n'
                           '    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * '
                           'synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as '
                           'many books do not even mention it (and it works without trimming)\n'
                           '    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A '
                           'single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, '
                           "IEEE International Conference on ICASSP'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n"
                           '    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # '
                           'computing the erasures locator polynomial\n'
                           '    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome '
                           'to get the untrimmed forney syndrome\n'
                           '    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are '
                           'useless. Seems to be not necessary, but this reduces the computation time later in BM '
                           "(thus it's an optimization).\n"
                           '\n'
                           '    return fsynd\n'
                           '\n'
                           'def rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        # Note that it is in fact possible to encode/decode messages that are longer '
                           'than field_charac, but because this will be above the field, this will generate more '
                           'error positions during Chien Search than it should, because this will generate '
                           "duplicate values, which should normally be prevented thank's to the prime polynomial "
                           "reduction (eg, because it can't discriminate between error at position 1 or 256, both "
                           "being exactly equal under galois field 2^8). So it's really not advised to do it, but "
                           "it's possible (but then you're not guaranted to be able to correct any error/erasure "
                           'on symbols with a position above the length of field_charac -- if you really need a '
                           'bigger message without chunking, then you should better enlarge c_exp so that you get '
                           'a bigger field).\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures to correct (beyond the Singleton bound)\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n'
                           '\n'
                           '    # Find errors locations\n'
                           '    if only_erasures:\n'
                           '        err_pos = []\n'
                           '    else:\n'
                           '        # compute the Forney syndromes, which hide the erasures from the original '
                           'syndrome (so that BM will just have to deal with errors, not erasures)\n'
                           '        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n'
                           '        # compute the error locator polynomial using Berlekamp-Massey\n'
                           '        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n'
                           '        # locate the message errors using Chien search (or bruteforce search)\n'
                           '        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n'
                           '        if err_pos is None:\n'
                           '            raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # Find errors values and apply them to correct the message\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # '
                           'note that we here use the original syndrome, not the forney syndrome (because we will '
                           'correct both errors and erasures, so we need the full syndrome)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function, without using the modified Forney "
                           "syndromes'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n'
                           '\n'
                           '    # prepare erasures locator and evaluator polynomials\n'
                           '    erase_loc = None\n'
                           '    #erase_eval = None\n'
                           '    erase_count = 0\n'
                           '    if erase_pos:\n'
                           '        erase_count = len(erase_pos)\n'
                           '        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n'
                           '        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n'
                           '        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, '
                           'len(erase_loc)-1)\n'
                           '\n'
                           '    # prepare errors/errata locator polynomial\n'
                           '    if only_erasures:\n'
                           '        err_loc = erase_loc[::-1]\n'
                           '        #err_eval = erase_eval[::-1]\n'
                           '    else:\n'
                           '        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, '
                           'erase_count=erase_count)\n'
                           '        err_loc = err_loc[::-1]\n'
                           '        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], '
                           'len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary '
                           'since we already compute it at the same time as the error locator poly in BM)\n'
                           '\n'
                           '    # locate the message errors\n'
                           '    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the '
                           'errata locator polynomial (ie: the positions of the errors/errata)\n'
                           '    if err_pos is None:\n'
                           '        raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_check(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Returns true if the message + ecc has no error of false otherwise (may not "
                           'always catch a wrong decoding or a wrong message, particularly if there are too many '
                           "errors -- above the Singleton bound --, but it usually does)'''\n"
                           '    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n'
                           '\n'
                           '\n'
                           '#===================================================================================================\n'
                           '# API\n'
                           '#===================================================================================================\n'
                           'class RSCodec(object):\n'
                           "    '''\n"
                           '    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to '
                           'encode a\n'
                           '    (byte)string to include the RS correction code, and pass such an encoded '
                           '(byte)string to\n'
                           '    ``decode`` to extract the original message (if the number of errors allows for '
                           'correct decoding).\n'
                           '    The ``nsym`` argument is the length of the correction code, and it determines the '
                           'number of\n'
                           '    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n'
                           "    '''\n"
                           "    '''\n"
                           '    Modifications by rotorgit 2/3/2015:\n'
                           '    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n'
                           '    different primitive polynomial and non-zero first consecutive root (fcr).\n'
                           '    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n'
                           '    the class; leaving them out will default for previous values (0 and\n'
                           '    0x11d)\n'
                           "    '''\n"
                           '\n'
                           '    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, '
                           'single_gen=True):\n'
                           "        '''Initialize the Reed-Solomon codec. Note that different parameters change "
                           'the internal values (the ecc symbols, look-up table values, etc) but not the output '
                           'result (whether your message can be repaired or not, there is no influence of the '
                           'parameters).\n'
                           '        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n'
                           '        nsize : maximum length of each chunk. If higher than 255, will use a higher '
                           "Galois Field, but the algorithm's complexity and computational cost will raise "
                           'quadratically...\n'
                           '        single_gen : if you want to use the same RSCodec for different nsym parameters '
                           '(but nsize the same), then set single_gen = False.\n'
                           "        '''\n"
                           '\n'
                           '        # Auto-setup if galois field or message length is different than default '
                           '(exponent 8)\n'
                           '        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois '
                           'field, we resize the galois field\n'
                           '            # Get the next closest power of two\n'
                           '            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), '
                           '2))\n'
                           '        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n'
                           '            prim = find_prime_polys(generator=generator, c_exp=c_exp, '
                           'fast_primes=True, single=True)\n'
                           '            if nsize == 255:  # resize chunk size if not set\n'
                           '                nsize = int(2**c_exp - 1)\n'
                           '        if nsym >= nsize:\n'
                           "            raise ValueError('ECC symbols must be strictly less than the total message "
                           "length (nsym < nsize).')\n"
                           '\n'
                           '        # Memorize variables\n'
                           '        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be '
                           'r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate '
                           'r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and '
                           '0.5% erasures (5 symbols out of 10).\n'
                           '        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols '
                           "after encoding, for the message alone it's nsize-nsym)\n"
                           '        self.fcr = fcr # first consecutive root, can be any value between 0 and '
                           '(2**c_exp)-1\n'
                           '        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to '
                           'find a prime poly\n'
                           '        self.generator = generator # generator integer, must be prime\n'
                           "        self.c_exp = c_exp # exponent of the field's characteristic. This both defines "
                           "the maximum value per symbol and the maximum length of one chunk. By default it's "
                           "GF(2^8), do not change if you're not sure what it means.\n"
                           '\n'
                           '        # Initialize the look-up tables for easy and quick multiplication/division\n'
                           '        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, '
                           'c_exp)\n'
                           '        # Precompute the generator polynomials\n'
                           '        if single_gen:\n'
                           '            self.gen = {}\n'
                           '            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n'
                           '        else:\n'
                           '            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n'
                           '\n'
                           '    def chunk(self, data, chunksize):\n'
                           "        '''Split a long message into chunks'''\n"
                           '        for i in xrange(0, len(data), chunksize):\n'
                           '            # Split the long message in a chunk\n'
                           '            chunk = data[i:i+chunksize]\n'
                           '            yield chunk\n'
                           '\n'
                           '    def encode(self, data, nsym=None):\n'
                           "        '''Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the "
                           "length of the message because we use chunking'''\n"
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        enc = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize - self.nsym):\n'
                           '            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, '
                           'generator=self.generator, gen=self.gen[nsym]))\n'
                           '        return enc\n'
                           '\n'
                           '    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n'
                           "        '''Repair a message, whatever its size is, by using chunking. May return a "
                           'wrong result if number of errors > nsym.\n'
                           '        Note that it returns a couple of vars: the repaired messages, and the repaired '
                           'messages+ecc (useful for checking).\n'
                           '        Usage: rmes, rmesecc = RSCodec.decode(data).\n'
                           "        '''\n"
                           '        # erase_pos is a list of positions where you know (or greatly suspect at '
                           "least) there is an erasure (ie, wrong character but you know it's at this position). "
                           'Just input the list of all positions you know there are errors, and this method will '
                           'automatically split the erasures positions to attach to the corresponding data chunk.\n'
                           '\n'
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        dec = _bytearray()\n'
                           '        dec_full = _bytearray()\n'
                           '        errata_pos_all = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            # Extract the erasures for this chunk\n'
                           '            e_pos = []\n'
                           '            if erase_pos:\n'
                           '                # First extract the erasures for this chunk (all erasures below the '
                           'maximum chunk length)\n'
                           '                e_pos = [x for x in erase_pos if x < self.nsize]\n'
                           '                # Then remove the extract erasures from the big list and also '
                           "decrement all subsequent positions values by nsize (the current chunk's size) so as to "
                           'prepare the correct alignment for the next iteration\n'
                           '                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n'
                           '            # Decode/repair this chunk!\n'
                           '            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n'
                           '            dec.extend(rmes)\n'
                           '            dec_full.extend(rmes+recc)\n'
                           '            errata_pos_all.extend(errata_pos)\n'
                           '        return dec, dec_full, errata_pos_all\n'
                           '\n'
                           '    def check(self, data, nsym=None):\n'
                           "        '''Check if a message+ecc stream is not corrupted (or fully repaired). Note: "
                           "may return a wrong result if number of errors > nsym.'''\n"
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        check = []\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            check.append(rs_check(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator))\n'
                           '        return check\n'
                           '\n'
                           '    def maxerrata(self, errors=None, erasures=None, verbose=False):\n'
                           "        '''Return the Singleton Bound for the current codec, which is the max number "
                           'of errata (errors and erasures) that the codec can decode/correct.\n'
                           '        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try '
                           'to raise an exception, but it may also not detect any problem with the message and '
                           'return 0 errors.\n'
                           '        Hence why you should use checksums if your goal is to detect errors (as '
                           'opposed to correcting them), as checksums have no bounds on the number of errors, the '
                           'only limitation being the probability of collisions.\n'
                           '        By default, return a tuple wth the maximum number of errors (2nd output) OR '
                           'erasures (2nd output) that can be corrected.\n'
                           '        If errors or erasures (not both) is specified as argument, computes the '
                           'remaining **simultaneous** correction capacity (eg, if errors specified, compute the '
                           'number of erasures that can be simultaneously corrected).\n'
                           "        Set verbose to True to get print a report.'''\n"
                           '        nsym = self.nsym\n'
                           '        # Compute the maximum number of errors OR erasures\n'
                           "        maxerrors = int(nsym/2)  # always floor the number, we can't correct half a "
                           "symbol, it's all or nothing\n"
                           '        maxerasures = nsym\n'
                           '        # Compute the maximum of simultaneous errors AND erasures\n'
                           '        if erasures is not None and erasures >= 0:\n'
                           '            # We know the erasures count, we want to know how many errors we can '
                           'correct simultaneously\n'
                           '            if erasures > maxerasures:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerrors = int((nsym-erasures)/2)\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (maxerrors, erasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return maxerrors, erasures\n'
                           '        if errors is not None and errors >= 0:\n'
                           '            # We know the errors count, we want to know how many erasures we can '
                           'correct simultaneously\n'
                           '            if errors > maxerrors:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerasures = int(nsym-(errors*2))\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (errors, maxerasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return errors, maxerasures\n'
                           '        # Return a tuple with the maximum number of errors and erasures (independently '
                           'corrected)\n'
                           '        if verbose:\n'
                           "            print('This codec can correct up to %i errors and %i erasures "
                           "independently' % (maxerrors, maxerasures))\n"
                           '        return maxerrors, maxerasures\n',
       'service': '"""ZMQ app boundary. All sockets and Engine methods belong to one thread."""\n'
                  'import queue\n'
                  'import threading\n'
                  'import time\n'
                  'import zmq\n'
                  'from .engine import Engine\n'
                  '\n'
                  '\n'
                  'class Service:\n'
                  '    def __init__(self, config, transmit, incoming=None, sensor=None, transport_tick=None):\n'
                  '        self.c=config;self.transmit=transmit;self.incoming=incoming or queue.Queue()\n'
                  '        '
                  'self.sensor=sensor;self.transport_tick=transport_tick;self.stop_event=threading.Event()\n'
                  '        self.ready=threading.Event();self.error=None;self.thread=None\n'
                  '\n'
                  '    def start(self):\n'
                  '        '
                  "self.thread=threading.Thread(target=self.run,name='radio-mac',daemon=True);self.thread.start()\n"
                  "        if not self.ready.wait(5):raise RuntimeError('Radio service did not start')\n"
                  '        if self.error:raise RuntimeError(str(self.error))\n'
                  '\n'
                  '    def stop(self):\n'
                  '        self.stop_event.set()\n'
                  '        if self.thread:self.thread.join(5)\n'
                  '\n'
                  '    def run(self):\n'
                  '        '
                  'context=zmq.Context();commands=context.socket(zmq.PULL);events=context.socket(zmq.PUSH)\n'
                  '        commands.setsockopt(zmq.MAXMSGSIZE,1024*1024)\n'
                  '        for s in (commands,events):s.setsockopt(zmq.LINGER,0)\n'
                  '        engine=None\n'
                  '        try:\n'
                  "            commands.bind('tcp://127.0.0.1:'+str(self.c['commands_port']))\n"
                  "            events.bind('tcp://127.0.0.1:'+str(self.c['events_port']))\n"
                  '            def emit(event):\n'
                  '                try:events.send_json(event,zmq.NOBLOCK)\n'
                  '                except zmq.Again:pass # Durable snapshot recovers message events on reconnect.\n'
                  '            engine=Engine(self.c,self.transmit,emit)\n'
                  '            self.ready.set()\n'
                  '            while not self.stop_event.is_set():\n'
                  '                if self.transport_tick:self.transport_tick(engine)\n'
                  '                if self.sensor:\n'
                  '                    reading=self.sensor()\n'
                  '                    if reading is not None:engine.sense(*reading)\n'
                  '                for _ in range(100):\n'
                  '                    try:engine.receive(self.incoming.get_nowait())\n'
                  '                    except queue.Empty:break\n'
                  '                for _ in range(100):\n'
                  '                    try:cmd=commands.recv_json(zmq.NOBLOCK)\n'
                  '                    except zmq.Again:break\n'
                  '                    try:\n'
                  "                        if cmd.get('cmd')=='send':engine.enqueue(cmd)\n"
                  "                        elif cmd.get('cmd')=='hello':engine.snapshot()\n"
                  "                        elif cmd.get('cmd')=='threshold':\n"
                  "                            value=float(cmd['db'])\n"
                  "                            if not -140<=value<=20:raise ValueError('Threshold outside -140..20 "
                  "dB')\n"
                  "                            engine.c['cs_threshold_db']=value\n"
                  '                    except Exception as exc:\n'
                  '                        '
                  "emit(dict(event='status',id=cmd.get('id'),status='failed',reason=str(exc)))\n"
                  '                engine.tick();self.stop_event.wait(0.003)\n'
                  '        except Exception as exc:\n'
                  "            self.error=exc;self.ready.set();print('Radio service stopped:',exc,flush=True)\n"
                  '        finally:\n'
                  '            if engine:engine.close()\n'
                  '            commands.close();events.close();context.term()\n'}
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'

      class _EmbeddedRadioLoader(_abc.MetaPathFinder, _abc.Loader):
          def find_spec(self, fullname, path=None, target=None):
              prefix = '_pixel_pulse_radio.'
              if fullname.startswith(prefix) and fullname[len(prefix):] in _RADIO_SOURCES:
                  return _util.spec_from_loader(fullname, self)
              return None

          def create_module(self, spec):
              return None

          def exec_module(self, module):
              name = module.__name__.split('.')[-1]
              module.__file__ = '<Pixel Pulse GRC>/' + name + '.py'
              exec(compile(_RADIO_SOURCES[name], module.__file__, 'exec'), module.__dict__)

      if '_pixel_pulse_radio' not in _sys.modules:
          _package = _types.ModuleType('_pixel_pulse_radio')
          _package.__path__ = []
          _package.__package__ = '_pixel_pulse_radio'
          _sys.modules['_pixel_pulse_radio'] = _package
          _sys.meta_path.insert(0, _EmbeddedRadioLoader())

      from _pixel_pulse_radio.radio_blocks import MacBridge
      class blk(MacBridge):
          def __init__(self, config_path="configs/node_a.json"):
              super().__init__(config_path)
    config_path: os.environ.get("SDRCHAT_CONFIG", "configs/node_a.json")
  states: {}
- name: epy_nlms
  id: epy_block
  parameters:
    _source_code: |
      # Pixel Pulse: all project radio modules are embedded below.
      # No sdrchat checkout or separately supplied Python blocks are required.
      import importlib.abc as _abc
      import importlib.util as _util
      import sys as _sys
      import types as _types

      _RADIO_SOURCES = {'config': 'import json\n'
                 'from pathlib import Path\n'
                 '\n'
                 '\n'
                 'def load(path):\n'
                 '    path = Path(path).resolve()\n'
                 '    c = json.loads(path.read_text())\n'
                 "    if not 1 <= c['address'] <= 65534:\n"
                 "        raise ValueError('Node address must be 0x0001..0xFFFE')\n"
                 "    c['state_dir'] = str((path.parent / c['state_dir']).resolve())\n"
                 "    c['config_path'] = str(path)\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n'
                 '\n'
                 '\n'
                 'def addr(value):\n'
                 "    return f'0x{int(value):04X}'\n"
                 '\n'
                 '\n'
                 "_DEFAULT_CONFIG = {'address': 16170, 'name': 'User 1', 'frequency': 2426500000, 'uri': "
                 "'ip:192.168.1.10', 'commands_port': 5555, 'events_port': 5556, 'shared_key': "
                 "'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=', 'state_dir': './data/node_a', 'sample_rate': "
                 "2400000, 'cs_threshold_db': -35.0, 'cs_hysteresis_db': 3.0, 'difs_s': 0.02, 'slot_s': 0.015, "
                 "'ack_timeout_s': 1.0, 'retry_limit': 20, 'cw_min': [8, 16, 32], 'cw_max': 1024, 'aging_s': 30.0, "
                 "'tx_delay_s': 0.02, 'tx_guard_s': 0.01, 'tx_attenuation_db': 0.0, 'rx_gain_db': 45, 'nlms_taps': "
                 "7, 'nlms_mu': 0.2, 'nlms_dd_mu': 0.02, 'nlms_eps': 1e-06, 'correlation_threshold': 0.6, "
                 "'contacts': [], 'local_radio_configured': True}\n"
                 '_original_load = load\n'
                 '\n'
                 'def load(path):\n'
                 '    import os\n'
                 '    path = Path(path)\n'
                 '    if path.exists():\n'
                 '        return _original_load(path)\n'
                 "    if os.environ.get('SDRCHAT_CONFIG') or str(path) != 'configs/node_a.json':\n"
                 "        raise FileNotFoundError('Node configuration does not exist: ' + str(path))\n"
                 '    c = dict(_DEFAULT_CONFIG)\n'
                 "    c['state_dir'] = str(Path(c['state_dir']).resolve())\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n',
       'engine': '"""Durable, single-flight ARQ with CSMA/CA. Owned by the radio process."""\n'
                 'import hashlib\n'
                 'import json\n'
                 'import random\n'
                 'import sqlite3\n'
                 'import time\n'
                 'import uuid\n'
                 'from collections import deque\n'
                 'from pathlib import Path\n'
                 'from cryptography.fernet import InvalidToken\n'
                 'from .protocol import Codec, TEXT, ACK, BROADCAST, make_fragment, parse_fragment\n'
                 '\n'
                 '\n'
                 'class Engine:\n'
                 '    def __init__(self, config, transmit, event, clock=time.monotonic, rng=None):\n'
                 "        self.c=config; self.me=config['address']; self.transmit=transmit; self.event=event\n"
                 '        self.clock=clock; self.rng=rng or random.SystemRandom(); '
                 "self.codec=Codec(config['shared_key'])\n"
                 "        self.db=sqlite3.connect(str(Path(config['state_dir'])/'radio.sqlite'))\n"
                 "        self.db.execute('PRAGMA journal_mode=WAL'); self.db.execute('PRAGMA synchronous=FULL')\n"
                 "        self.db.executescript('''\n"
                 '        CREATE TABLE IF NOT EXISTS jobs(id TEXT PRIMARY KEY,dst INTEGER,priority INTEGER,kind '
                 'TEXT,name TEXT,data BLOB,created REAL,status TEXT,part INTEGER DEFAULT 0);\n'
                 '        CREATE TABLE IF NOT EXISTS fragments(src INTEGER,id TEXT,part INTEGER,total INTEGER,meta '
                 'TEXT,data BLOB,PRIMARY KEY(src,id,part));\n'
                 '        CREATE TABLE IF NOT EXISTS receipts(src INTEGER,seq INTEGER,digest TEXT,PRIMARY '
                 'KEY(src,seq));\n'
                 '        CREATE TABLE IF NOT EXISTS received(src INTEGER,id TEXT,kind TEXT,name TEXT,data '
                 'BLOB,PRIMARY KEY(src,id));\n'
                 '        CREATE TABLE IF NOT EXISTS settings(key TEXT PRIMARY KEY,value INTEGER);\n'
                 "        ''')\n"
                 '        self.db.execute("INSERT OR IGNORE INTO settings '
                 'VALUES(\'sequence\',?)",(self.rng.randrange(1,2**30),))\n'
                 '        self.db.execute("UPDATE jobs SET status=\'queued\' WHERE status IN '
                 '(\'sending\',\'sent\')")\n'
                 '        self.db.commit()\n'
                 '        self.queues=[deque(),deque(),deque()]\n'
                 '        self.jobs={}; self.current=None; self.flight=None; self.acks=deque(); '
                 'self.ack_keys=set()\n'
                 '        self.contender=None; self.idle_since=None; self.tx_until=0; self.busy=True\n'
                 '        self.power=-200.; self.sense_at=-1e9; self.last_status=-1e9\n'
                 '        for row in self.db.execute("SELECT id,dst,priority,kind,name,data,created,part FROM jobs '
                 'WHERE status=\'queued\' ORDER BY created,rowid"):\n'
                 "            j=dict(zip(('id','dst','priority','kind','name','data','created','part'),row))\n"
                 "            j['enqueued']=self.clock()-max(0,time.time()-j['created']); self.jobs[j['id']]=j\n"
                 "            self.queues[j['priority']].append(j)\n"
                 '\n'
                 '    def close(self):\n'
                 '        self.db.close()\n'
                 '\n'
                 '    def status(self, ident, state, **extra):\n'
                 "        self.db.execute('UPDATE jobs SET status=? WHERE id=?',(state,ident)); self.db.commit()\n"
                 "        self.event(dict(event='status',id=ident,status='sent' if state=='broadcast_sent' else "
                 'state,**extra))\n'
                 '\n'
                 '    def enqueue(self, command):\n'
                 "        ident=str(uuid.UUID(command['id']))\n"
                 "        found=self.db.execute('SELECT status FROM jobs WHERE id=?',(ident,)).fetchone()\n"
                 '        if found:\n'
                 "            self.event(dict(event='status',id=ident,status='sent' if found[0]=='broadcast_sent' "
                 'else found[0])); return\n'
                 "        dst=int(command['dst']); pri=int(command['priority']); kind=command['kind']\n"
                 '        if dst==self.me or not 1<=dst<=BROADCAST or pri not in (0,1,2):\n'
                 "            raise ValueError('Invalid destination or priority')\n"
                 "        if kind=='text':\n"
                 "            data=command['text'].encode('utf-8'); name='message.txt'\n"
                 "            if not 0<len(data)<=65536: raise ValueError('Text must contain 1..65536 UTF-8 "
                 "bytes')\n"
                 "        elif kind in ('image','audio','file'):\n"
                 "            p=Path(command['path']).resolve()\n"
                 '            if not p.is_file() or not 0<p.stat().st_size<=16*1024*1024:\n'
                 "                raise ValueError('Choose a nonempty file up to 16 MiB')\n"
                 "            data=p.read_bytes(); name=str(command.get('name',p.name))[:120]\n"
                 "        else: raise ValueError('Unknown message type')\n"
                 '        j=dict(id=ident,dst=dst,priority=pri,kind=kind,name=name,data=data,\n'
                 '               created=time.time(),part=0,enqueued=self.clock())\n'
                 "        self.db.execute('INSERT INTO jobs VALUES(?,?,?,?,?,?,?,?,?)',\n"
                 "            (ident,dst,pri,kind,name,data,j['created'],'queued',0)); self.db.commit()\n"
                 '        self.jobs[ident]=j; self.queues[pri].append(j)\n'
                 "        self.status(ident,'queued')\n"
                 '\n'
                 '    def snapshot(self):\n'
                 "        for ident,status in self.db.execute('SELECT id,status FROM jobs'):\n"
                 "            self.event(dict(event='status',id=ident,status='sent' if status=='broadcast_sent' "
                 'else status))\n'
                 "        for src,ident,kind,name,data in self.db.execute('SELECT src,id,kind,name,data FROM "
                 "received'):\n"
                 '            self.deliver_event(src,ident,kind,name,data)\n'
                 '\n'
                 '    def deliver_event(self, src, ident, kind, name, data):\n'
                 "        info=dict(event='received',id=ident,src=src,kind=kind,name=name)\n"
                 "        if kind=='text': info['text']=data.decode('utf-8')\n"
                 '        else:\n'
                 "            directory=Path(self.c['state_dir'])/'received'; directory.mkdir(exist_ok=True)\n"
                 "            safe=''.join(c if c.isalnum() or c in '.-_ ' else '_' for c in "
                 'Path(name).name)[:120]\n'
                 "            path=directory/(str(src)+'_'+ident+'_'+safe)\n"
                 '            if not path.exists():\n'
                 '                '
                 "temp=path.with_suffix(path.suffix+'.part');temp.write_bytes(data);temp.replace(path)\n"
                 "            info['path']=str(path)\n"
                 '        self.event(info)\n'
                 '\n'
                 '    def sense(self, power_db, busy=None):\n'
                 '        self.power=float(power_db); self.sense_at=self.clock()\n'
                 '        if busy is None:\n'
                 "            limit=self.c['cs_threshold_db']-(self.c['cs_hysteresis_db'] if self.busy else 0)\n"
                 '            self.busy=self.power>limit\n'
                 '        else:self.busy=bool(busy)\n'
                 '        if self.busy:\n'
                 '            self.idle_since=None\n'
                 "            if self.contender:self.contender.pop('slot_at',None)\n"
                 '\n'
                 '    def receive(self, wire):\n'
                 '        try:\n'
                 '            f=self.codec.unpack(wire,self.me)\n'
                 "            if f['typ']==ACK:\n"
                 '                p=self.flight\n'
                 "                if p and p.get('sent_once') and f['dst']==self.me and f['src']==p['dst'] and "
                 "f['seq']==p['seq'] and f['body']==uuid.UUID(self.current['id']).bytes:\n"
                 '                    self.complete_packet()\n'
                 '                return\n'
                 '            digest=hashlib.sha256(wire).hexdigest()\n'
                 "            receipt=self.db.execute('SELECT digest FROM receipts WHERE src=? AND "
                 "seq=?',(f['src'],f['seq'])).fetchone()\n"
                 "            ident,index,count,meta,data=parse_fragment(f['body'])\n"
                 '            if receipt and receipt[0]!=digest: return\n'
                 '            if not receipt:\n'
                 '                # Completed messages may be retransmitted with a new sequence after a restart.\n'
                 "                done=self.db.execute('SELECT 1 FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 '                if not done:\n'
                 '                    m=json.dumps(meta,sort_keys=True)\n'
                 "                    existing=self.db.execute('SELECT meta,data FROM fragments WHERE src=? AND "
                 "id=? AND part=?',(f['src'],ident,index)).fetchone()\n"
                 "                    if existing and existing!=(m,data):raise ValueError('Conflicting fragment')\n"
                 "                    other=self.db.execute('SELECT meta FROM fragments WHERE src=? AND id=? LIMIT "
                 "1',(f['src'],ident)).fetchone()\n"
                 "                    if other and other[0]!=m:raise ValueError('Conflicting metadata')\n"
                 "                    self.db.execute('INSERT OR IGNORE INTO fragments "
                 "VALUES(?,?,?,?,?,?)',(f['src'],ident,index,count,m,data))\n"
                 "                    rows=self.db.execute('SELECT data FROM fragments WHERE src=? AND id=? ORDER "
                 "BY part',(f['src'],ident)).fetchall()\n"
                 '                    if len(rows)==count:\n'
                 "                        full=b''.join(r[0] for r in rows)\n"
                 "                        if len(full)!=meta['size'] or "
                 "hashlib.sha256(full).hexdigest()!=meta['sha256']:\n"
                 "                            raise ValueError('Whole-message SHA-256 failure')\n"
                 "                        if meta['kind']=='text':full.decode('utf-8')\n"
                 "                        self.db.execute('INSERT INTO received "
                 "VALUES(?,?,?,?,?)',(f['src'],ident,meta['kind'],meta['name'],full))\n"
                 "                        self.db.execute('DELETE FROM fragments WHERE src=? AND "
                 "id=?',(f['src'],ident))\n"
                 "                self.db.execute('INSERT INTO receipts "
                 "VALUES(?,?,?)',(f['src'],f['seq'],digest)); self.db.commit()\n"
                 '                # Reconstruct delivery event from durable storage, before acknowledging '
                 'completion.\n'
                 "                received=self.db.execute('SELECT kind,name,data FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 "                if received:self.deliver_event(f['src'],ident,*received)\n"
                 "            if f['dst']!=BROADCAST and (f['src'],f['seq']) not in self.ack_keys:\n"
                 "                self.ack_keys.add((f['src'],f['seq']))\n"
                 "                raw=self.codec.pack(f['src'],self.me,f['seq'],0,ACK,uuid.UUID(ident).bytes)\n"
                 '                '
                 "self.acks.append(dict(wire=raw,ack=True,dst=f['src'],seq=f['seq'],cw=4,slots=None))\n"
                 '        except (ValueError,KeyError,TypeError,InvalidToken,UnicodeError) as exc:\n'
                 '            self.db.rollback()\n'
                 "            self.event(dict(event='diagnostic',message='RX rejected: '+str(exc)))\n"
                 '\n'
                 '    def choose(self):\n'
                 '        now=self.clock()\n'
                 "        heads=[(max(0,p-int((now-q[0]['enqueued'])/self.c['aging_s'])),q[0]['created'],p) for "
                 'p,q in enumerate(self.queues) if q]\n'
                 '        if not heads:return None\n'
                 '        _,_,p=min(heads)\n'
                 '        return self.queues[p].popleft()\n'
                 '\n'
                 '    def new_packet(self):\n'
                 '        j=self.current\n'
                 '        seq=self.db.execute("SELECT value FROM settings WHERE key=\'sequence\'").fetchone()[0]\n'
                 "        if seq>=0xFFFFFFFF:raise RuntimeError('Sequence space exhausted; provision a new node "
                 "address')\n"
                 '        self.db.execute("UPDATE settings SET value=? WHERE '
                 'key=\'sequence\'",(seq+1,));self.db.commit()\n'
                 "        body,count=make_fragment(j,j['part'])\n"
                 "        self.flight=dict(wire=self.codec.pack(j['dst'],self.me,seq,j['priority'],TEXT,body),\n"
                 '                         '
                 "dst=j['dst'],seq=seq,retries=0,cw=self.c['cw_min'][j['priority']],slots=None,\n"
                 '                         deadline=None,ack=False,count=count)\n'
                 '\n'
                 '    def complete_packet(self):\n'
                 '        j=self.current;p=self.flight\n'
                 '        if self.contender is p:self.contender=None\n'
                 "        j['part']+=1\n"
                 "        self.db.execute('UPDATE jobs SET part=? WHERE "
                 "id=?',(j['part'],j['id']));self.db.commit()\n"
                 '        self.flight=None\n'
                 "        if j['part']>=p['count']:\n"
                 "            self.status(j['id'],'broadcast_sent' if j['dst']==BROADCAST else "
                 "'delivered',broadcast=j['dst']==BROADCAST)\n"
                 "            self.jobs.pop(j['id'],None);self.current=None\n"
                 '        else:\n'
                 "            self.status(j['id'],'sending',progress=j['part']/p['count'])\n"
                 "            self.queues[j['priority']].appendleft(j);self.current=None\n"
                 '\n'
                 '    def tick(self):\n'
                 '        now=self.clock()\n'
                 '        if now-self.last_status>=0.5:\n'
                 "            self.event(dict(event='telemetry',power_db=self.power,busy=self.busy,\n"
                 '                            waiting=sum(map(len,self.queues)),active=bool(self.current),\n'
                 '                            queues=[len(q) for q in self.queues],address=self.me))\n'
                 '            self.last_status=now\n'
                 '        if now<self.tx_until:\n'
                 '            self.idle_since=None;return\n'
                 "        if self.flight and self.flight.get('broadcast_done'):\n"
                 '            self.complete_packet()\n'
                 "        if self.flight and self.flight['deadline'] is not None and "
                 "now>=self.flight['deadline']:\n"
                 '            p=self.flight\n'
                 "            if p['retries']>=self.c['retry_limit']:\n"
                 "                self.status(self.current['id'],'failed',reason='ACK timeout: retry limit "
                 "reached')\n"
                 "                self.jobs.pop(self.current['id'],None);self.current=None;self.flight=None\n"
                 '                if self.contender is p:self.contender=None\n'
                 '            else:\n'
                 "                p['retries']+=1;p['cw']=min(self.c['cw_max'],p['cw']*2)\n"
                 "                p['deadline']=None;p['slots']=None\n"
                 "                self.status(self.current['id'],'sending',retry=p['retries'])\n"
                 '        if self.current is None:\n'
                 '            self.current=self.choose()\n'
                 '        if self.current and self.flight is None:self.new_packet()\n'
                 '        # ACKs have a separate control queue. They never wait behind a data ACK timeout.\n'
                 '        if self.acks:\n'
                 '            candidate=self.acks[0]\n'
                 "        elif self.flight and self.flight['deadline'] is None:\n"
                 '            candidate=self.flight\n'
                 '        else:\n'
                 '            self.contender=None;return\n'
                 '        if candidate is not self.contender:\n'
                 "            self.contender=candidate; self.idle_since=None;candidate.pop('slot_at',None)\n"
                 '        if self.busy or now-self.sense_at>0.2:\n'
                 "            self.idle_since=None;candidate.pop('slot_at',None);return\n"
                 '        if self.idle_since is None:self.idle_since=now\n'
                 "        if now-self.idle_since<self.c['difs_s']:return\n"
                 "        if candidate['slots'] is None:\n"
                 "            candidate['slots']=self.rng.randrange(candidate['cw']);candidate['slot_at']=now\n"
                 "        elif 'slot_at' not in candidate:candidate['slot_at']=now\n"
                 "        slots=int((now-candidate['slot_at'])/self.c['slot_s'])\n"
                 "        candidate['slots']=max(0,candidate['slots']-slots)\n"
                 "        candidate['slot_at']+=slots*self.c['slot_s']\n"
                 "        if candidate['slots']:return\n"
                 "        if not candidate['ack']:self.status(self.current['id'],'sending')\n"
                 "        try:duration=float(self.transmit(candidate['wire']))\n"
                 '        except Exception as exc:\n'
                 "            self.event(dict(event='diagnostic',message='TX unavailable: '+str(exc)))\n"
                 "            candidate['slots']=None;self.idle_since=None;return\n"
                 '        self.tx_until=now+duration;self.idle_since=None;self.contender=None\n'
                 "        if candidate['ack']:\n"
                 "            self.acks.popleft();self.ack_keys.discard((candidate['dst'],candidate['seq']))\n"
                 '        else:\n'
                 "            candidate['sent_once']=True\n"
                 "            candidate['deadline']=self.tx_until+self.c['ack_timeout_s']\n"
                 "            if candidate['dst']==BROADCAST:candidate['broadcast_done']=True\n"
                 "            self.status(self.current['id'],'sent',retry=candidate['retries'])\n",
       'equalizer': 'import ctypes\n'
                    'import hashlib\n'
                    'from pathlib import Path\n'
                    'import numpy as np\n'
                    'import pmt\n'
                    'from gnuradio import gr\n'
                    '\n'
                    '\n'
                    'def training_bytes(length=2048):\n'
                    "    return b''.join(hashlib.sha256(b'QPSK-training-v1'+i.to_bytes(4,'big')).digest()\n"
                    '                    for i in range((length+31)//32))[:length]\n'
                    '\n'
                    '\n'
                    'def training_symbols():\n'
                    '    # Last 64 bytes of the EXISTING deterministic prefix. Constant differential\n'
                    '    # phase before this segment is absorbed by training; no change to TX bytes.\n'
                    '    bits=np.unpackbits(np.frombuffer(training_bytes()[-64:],dtype=np.uint8)).reshape(-1,2)\n'
                    '    chunks=bits[:,0]*2+bits[:,1]\n'
                    '    mapped=np.array([0,1,3,2])[chunks]\n'
                    '    index=np.cumsum(mapped)%4\n'
                    '    return np.array([.707+.707j,-.707+.707j,-.707-.707j,.707-.707j],np.complex64)[index]\n'
                    '\n'
                    '\n'
                    'class TrainingCorrelator(gr.sync_block):\n'
                    '    def __init__(self, threshold=.6):\n'
                    "        gr.sync_block.__init__(self,name='QPSK training "
                    "correlator',in_sig=[np.complex64],out_sig=[np.complex64])\n"
                    '        symbols=training_symbols()[:64]\n'
                    '        t=np.arange(-8,9)/2.;a=.35\n'
                    '        pulse=np.sinc(t)*np.cos(np.pi*a*t)/(1-(2*a*t)**2)\n'
                    '        '
                    'self.ref=np.convolve(np.kron(symbols,[1,0]),pulse)[8:8+2*len(symbols)-1].astype(np.complex64)\n'
                    '        self.energy=float(np.vdot(self.ref,self.ref).real);self.threshold=threshold\n'
                    '        self.delay=(len(self.ref)+9)//2*2\n'
                    '        self.set_history(self.delay+1);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '        self.next_position=0;self.last_position=-10000;self.count=0\n'
                    '\n'
                    '    def work(self, inputs, outputs):\n'
                    '        x=inputs[0];out=outputs[0];n=len(out);out[:]=x[:n]\n'
                    '        base=self.nitems_written(0)-self.delay\n'
                    "        c=np.correlate(x,self.ref,'valid')\n"
                    "        power=np.convolve(np.abs(x).astype(np.float64)**2,np.ones(len(self.ref)),'valid')\n"
                    '        score=np.abs(c)**2/(self.energy*power+1e-12)\n'
                    '        '
                    'lo=max(self.next_position-base,2,-base);hi=min(len(score)-3,n+self.delay-len(self.ref))\n'
                    '        for j in np.flatnonzero(score[lo:hi+1]>self.threshold)+lo:\n'
                    '            if score[j]<max(score[j-2:j]) or score[j]<=max(score[j+1:j+3]):continue\n'
                    '            absolute=base+int(j)\n'
                    '            if absolute-self.last_position<512:continue\n'
                    '            offset=absolute+self.delay\n'
                    '            if offset<self.nitems_written(0):continue\n'
                    '            '
                    "self.add_item_tag(0,offset,pmt.intern('corr_est'),pmt.from_double(float(score[j])))\n"
                    '            self.last_position=absolute;self.count+=1\n'
                    '        if hi>=lo:self.next_position=base+hi+1\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    'class NLMS(gr.decim_block):\n'
                    '    def __init__(self,taps=7,mu=.2,dd_mu=.02,eps=1e-6):\n'
                    "        gr.decim_block.__init__(self,name='Regularized QPSK "
                    "NLMS',in_sig=[np.complex64],out_sig=[np.complex64],decim=2)\n"
                    '        if taps<3 or taps%2!=1 or not 0<mu<2 or not 0<dd_mu<2 or eps<=0:raise '
                    "ValueError('Invalid NLMS parameters')\n"
                    '        self.taps=taps;self.mu=mu;self.dd_mu=dd_mu;self.eps=eps\n'
                    '        self.weights=np.zeros(taps,np.complex64);self.weights[0]=1\n'
                    '        '
                    'self.training=training_symbols();self.pos=ctypes.c_int(0);self.active=ctypes.c_int(0)\n'
                    '        lib=_embedded_native_library()\n'
                    "        if not lib.exists():raise RuntimeError('Run ./setup.sh to build the NLMS kernel')\n"
                    '        self.lib=ctypes.CDLL(str(lib));self.fn=self.lib.nlms_process\n'
                    '        '
                    'self.fn.argtypes=[ctypes.c_void_p,ctypes.c_void_p,ctypes.c_int,ctypes.c_int,ctypes.c_void_p,\n'
                    '            '
                    'ctypes.c_void_p,ctypes.c_int,ctypes.POINTER(ctypes.c_int),ctypes.POINTER(ctypes.c_int),\n'
                    '            '
                    'ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_void_p,ctypes.c_int]\n'
                    '        '
                    'self.fn.restype=None;self.set_history(taps);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '\n'
                    '    def work(self,inputs,outputs):\n'
                    '        x=inputs[0];y=outputs[0];n=len(y)\n'
                    "        tags=self.get_tags_in_window(0,0,2*n,pmt.intern('corr_est'))\n"
                    '        starts=np.array([int(t.offset-self.nitems_read(0)) for t in tags],np.int32)\n'
                    '        self.fn(x.ctypes.data,y.ctypes.data,n,self.taps,self.weights.ctypes.data,\n'
                    '                '
                    'self.training.ctypes.data,len(self.training),ctypes.byref(self.pos),ctypes.byref(self.active),\n'
                    '                self.mu,self.dd_mu,self.eps,1e-8,starts.ctypes.data,len(starts))\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    "_NATIVE_SOURCE = '// Batched regularized complex NLMS. y = w^H x, e = d-y.\\n#include "
                    '<complex>\\n#include <cmath>\\n#include <algorithm>\\nusing C = std::complex<float>;\\nextern '
                    '"C" void nlms_process(const C* input, C* output, int n, int '
                    'taps,\\n                              C* weights, const C* training, int '
                    'training_len,\\n                              int* training_pos, int* active, float '
                    'mu,\\n                              float dd_mu, float eps, float '
                    'gate,\\n                              const int* starts, int nstarts) {\\n    int '
                    'tag=0;\\n    for(int i=0;i<n;i++) {\\n        if(tag<nstarts && starts[tag]<=2*i+1) '
                    '{\\n            *training_pos=0;*active=1;tag++;\\n            '
                    'std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);\\n        }\\n        const C* '
                    'newest=input+taps-1+2*i;\\n        C y(0,0);float power=0;\\n        for(int k=0;k<taps;k++) '
                    '{y+=std::conj(weights[k])*newest[-k];power+=std::norm(newest[-k]);}\\n        '
                    'output[i]=y;\\n        if(!*active || power<gate || !std::isfinite(power))continue;\\n        '
                    'bool train=*training_pos<training_len;\\n        C '
                    'desired=train?training[(*training_pos)++]:C(y.real()>=0?.707f:-.707f,y.imag()>=0?.707f:-.707f);\\n        '
                    'C error=desired-y;\\n        float step=(train?mu:dd_mu)/(eps+power);\\n        for(int '
                    'k=0;k<taps;k++)weights[k]+=step*std::conj(error)*newest[-k];\\n        // Disable adaptation '
                    'on catastrophic divergence; reacquire on next preamble.\\n        '
                    'if(!std::isfinite(std::norm(y)) || std::norm(y)>1e6f) '
                    "{*active=0;std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);}\\n    }\\n}\\n'\n"
                    '_native_directory = None\n'
                    '\n'
                    'def _embedded_native_library():\n'
                    '    global _native_directory\n'
                    '    import shutil\n'
                    '    import subprocess\n'
                    '    import tempfile\n'
                    '    if _native_directory is None:\n'
                    "        compiler = shutil.which('g++')\n"
                    '        if compiler is None:\n'
                    "            raise RuntimeError('The embedded NLMS source needs g++. Install g++ and run "
                    "again.')\n"
                    "        directory = tempfile.TemporaryDirectory(prefix='pixel-pulse-nlms-')\n"
                    '        folder = Path(directory.name)\n'
                    "        source = folder / 'nlms.cpp'\n"
                    '        source.write_text(_NATIVE_SOURCE)\n'
                    '        try:\n'
                    "            subprocess.run([compiler, '-O3', '-std=c++17', '-shared', '-fPIC', str(source), "
                    "'-o', str(folder / 'libnlms.so')], check=True, capture_output=True, text=True)\n"
                    '        except subprocess.CalledProcessError as exc:\n'
                    '            directory.cleanup()\n'
                    "            raise RuntimeError('Could not compile embedded NLMS source: ' + exc.stderr) from "
                    'exc\n'
                    '        _native_directory = directory\n'
                    "    return Path(_native_directory.name) / 'libnlms.so'\n",
       'protocol': '"""Network-order routing header + authenticated encrypted fragment or ACK.\n'
                   '\n'
                   'The GNU Radio graph adds CRC32 and RS outside this layer. The simulator uses\n'
                   'the same CRC and RS codec. Routing fields are repeated inside Fernet so they\n'
                   'cannot be altered without authentication failure.\n'
                   '"""\n'
                   'import hashlib\n'
                   'import json\n'
                   'import struct\n'
                   'import uuid\n'
                   'import zlib\n'
                   'from cryptography.fernet import Fernet\n'
                   'from .reedsolo_bundled import RSCodec\n'
                   '\n'
                   'TEXT, ACK = 1, 2\n'
                   'BROADCAST = 0xFFFF\n'
                   "HEADER = struct.Struct('!HHIBBH')\n"
                   "ROUTE = struct.Struct('!HHIBB')\n"
                   "FRAGMENT = struct.Struct('!16sHHH')\n"
                   '\n'
                   '\n'
                   'class Codec:\n'
                   '    def __init__(self, key):\n'
                   '        self.cipher = Fernet(key.encode() if isinstance(key, str) else key)\n'
                   '        self.rs = RSCodec(16, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8)\n'
                   '\n'
                   '    def pack(self, dst, src, seq, priority, typ, body):\n'
                   '        if not 1 <= src < BROADCAST or not 1 <= dst <= BROADCAST:\n'
                   "            raise ValueError('Invalid address')\n"
                   '        if priority not in (0, 1, 2) or typ not in (TEXT, ACK):\n'
                   "            raise ValueError('Invalid priority or packet type')\n"
                   '        route = ROUTE.pack(dst, src, seq, priority, typ)\n'
                   '        token = self.cipher.encrypt(route + body)\n'
                   '        wire = HEADER.pack(dst, src, seq, priority, typ, len(token)) + token\n'
                   '        if len(wire) > 4092:\n'
                   "            raise ValueError('Frame exceeds original 4092-byte budget')\n"
                   '        return wire\n'
                   '\n'
                   '    def unpack(self, wire, me):\n'
                   '        if len(wire) < HEADER.size or len(wire) > 4092:\n'
                   "            raise ValueError('Invalid frame size')\n"
                   '        dst, src, seq, pri, typ, length = HEADER.unpack_from(wire)\n'
                   '        if dst not in (me, BROADCAST) or src == me or not 1 <= src < BROADCAST:\n'
                   "            raise ValueError('Frame for another node or own echo')\n"
                   '        if length != len(wire)-HEADER.size or pri not in (0,1,2) or typ not in (TEXT,ACK):\n'
                   "            raise ValueError('Malformed header')\n"
                   '        raw = self.cipher.decrypt(wire[HEADER.size:])\n'
                   '        if raw[:ROUTE.size] != ROUTE.pack(dst,src,seq,pri,typ):\n'
                   "            raise ValueError('Authenticated routing mismatch')\n"
                   '        return dict(dst=dst, src=src, seq=seq, priority=pri, typ=typ, body=raw[ROUTE.size:])\n'
                   '\n'
                   '    def protect(self, raw):\n'
                   "        data = raw + struct.pack('!I', zlib.crc32(raw))\n"
                   '        return bytes(self.rs.encode(data))\n'
                   '\n'
                   '    def recover(self, coded):\n'
                   '        data = bytes(self.rs.decode(coded)[0])\n'
                   "        if len(data)<4 or zlib.crc32(data[:-4]) != struct.unpack('!I',data[-4:])[0]:\n"
                   "            raise ValueError('CRC failure')\n"
                   '        return data[:-4]\n'
                   '\n'
                   '\n'
                   'def make_fragment(job, index):\n'
                   "    data = job['data']\n"
                   "    chunk = 128 if job['kind']=='text' else 1024\n"
                   '    count = max(1, (len(data)+chunk-1)//chunk)\n'
                   "    meta = json.dumps(dict(kind=job['kind'], name=job['name'], size=len(data),\n"
                   '                           '
                   "sha256=hashlib.sha256(data).hexdigest()),separators=(',',':')).encode()\n"
                   '    return '
                   "FRAGMENT.pack(uuid.UUID(job['id']).bytes,index,count,len(meta))+meta+data[index*chunk:(index+1)*chunk], "
                   'count\n'
                   '\n'
                   '\n'
                   'def parse_fragment(body):\n'
                   '    if len(body)<FRAGMENT.size:\n'
                   "        raise ValueError('Truncated fragment')\n"
                   '    ident,index,count,mlen = FRAGMENT.unpack_from(body)\n'
                   '    if not 1<=count<=16384 or index>=count or not 0<mlen<=1024:\n'
                   "        raise ValueError('Invalid fragmentation')\n"
                   '    meta = json.loads(body[FRAGMENT.size:FRAGMENT.size+mlen])\n'
                   "    if meta['kind'] not in ('text','image','audio','file') or not "
                   "0<meta['size']<=16*1024*1024:\n"
                   "        raise ValueError('Invalid transfer metadata')\n"
                   "    chunk = 128 if meta['kind']=='text' else 1024\n"
                   "    if meta['kind']=='text' and meta['size']>65536:\n"
                   "        raise ValueError('Text exceeds original 64 KiB limit')\n"
                   "    if count != (meta['size']+chunk-1)//chunk:\n"
                   "        raise ValueError('Wrong fragment count')\n"
                   '    data=body[FRAGMENT.size+mlen:]\n'
                   "    if len(data)!=min(chunk,meta['size']-index*chunk):\n"
                   "        raise ValueError('Wrong fragment length')\n"
                   '    return str(uuid.UUID(bytes=ident)),index,count,meta,data\n',
       'radio_blocks': 'import os\n'
                       'import queue\n'
                       'import threading\n'
                       'import time\n'
                       'import numpy as np\n'
                       'import pmt\n'
                       'from gnuradio import gr\n'
                       'from .config import load\n'
                       'from .service import Service\n'
                       '\n'
                       '\n'
                       'def airtime(c, raw_length):\n'
                       '    """Estimate a framed RF burst including host delay and turnaround guard."""\n'
                       '    coded=raw_length+4+16*((raw_length+4+238)//239)\n'
                       "    return (2048+12+coded+2570)*16/c['sample_rate']+c['tx_delay_s']+c['tx_guard_s']\n"
                       '\n'
                       '\n'
                       'class MacBridge(gr.sync_block):\n'
                       '    """Raw RX energy observer + PDU socket/MAC service. No stream output."""\n'
                       "    def __init__(self,config_path='configs/node_a.json'):\n"
                       "        gr.sync_block.__init__(self,name='CSMA/CA + app "
                       "bridge',in_sig=[np.complex64],out_sig=None)\n"
                       '        self.c=load(config_path);self.incoming=queue.Queue(maxsize=4096)\n'
                       '        '
                       'self.reading=None;self.read_at=0;self.lock=threading.Lock();self.tx_lock=threading.Lock()\n'
                       '        self.tx_at=0;self.tx_end=0;self.sink=None;self.source=None;self.muted=True\n'
                       '        '
                       "self.message_port_register_in(pmt.intern('rx_in'));self.set_msg_handler(pmt.intern('rx_in'),self.receive)\n"
                       "        self.message_port_register_out(pmt.intern('tx_out'))\n"
                       '        self.service=Service(self.c,self.send,self.incoming,self.sensor)\n'
                       '\n'
                       '    def attach_radio(self,sink,source):\n'
                       '        self.sink=sink;self.source=source\n'
                       '\n'
                       '    def start(self):\n'
                       "        if self.sink is None:raise RuntimeError('Launch with python3 -m sdrchat.hardware; "
                       "radio mute hook is required')\n"
                       '        self.sink.set_attenuation(0,89.75)\n'
                       '        self.service.start();return True\n'
                       '\n'
                       '    def stop(self):\n'
                       '        self.service.stop()\n'
                       '        if self.sink:self.sink.set_attenuation(0,89.75)\n'
                       '        return True\n'
                       '\n'
                       '    def sensor(self):\n'
                       '        now=time.monotonic()\n'
                       '        if not self.muted and now>=self.tx_end:\n'
                       '            self.sink.set_attenuation(0,89.75);self.muted=True\n'
                       '        with self.lock:\n'
                       '            if now-self.read_at>.1:return None\n'
                       '            return self.reading,None\n'
                       '\n'
                       '    def send(self,wire):\n'
                       "        if self.sink is None:raise RuntimeError('Radio sink not attached')\n"
                       "        self.sink.set_attenuation(0,self.c['tx_attenuation_db']);self.muted=False\n"
                       '        duration=airtime(self.c,len(wire))\n'
                       '        self.tx_at=time.monotonic();self.tx_end=self.tx_at+duration\n'
                       '        '
                       "self.message_port_pub(pmt.intern('tx_out'),pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(wire),list(wire))))\n"
                       '        return duration\n'
                       '\n'
                       '    def receive(self,msg):\n'
                       '        # Ignore own RF echo during the estimated transmission/turnaround window.\n'
                       '        if time.monotonic()<self.tx_end:return\n'
                       '        if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):\n'
                       '            try:self.incoming.put_nowait(bytes(pmt.u8vector_elements(pmt.cdr(msg))))\n'
                       '            except queue.Full:pass\n'
                       '\n'
                       '    def work(self,inputs,outputs):\n'
                       '        x=inputs[0]\n'
                       '        if len(x):\n'
                       '            power=10*np.log10(max(float(np.mean(np.abs(x)**2)),1e-20))\n'
                       '            with self.lock:self.reading=power;self.read_at=time.monotonic()\n'
                       '        return len(x)\n',
       'reedsolo_bundled': '#!/usr/bin/env python\n'
                           '# -*- coding: utf-8 -*-\n'
                           '\n'
                           '# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n'
                           '# Copyright (c) 2015 rotorgit\n'
                           '# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n'
                           '\n'
                           "'''\n"
                           'Reed Solomon\n'
                           '============\n'
                           '\n'
                           'A pure-python `universal errors-and-erasures Reed-Solomon Codec '
                           '<http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n'
                           ', based on the wonderful tutorial at\n'
                           '`wikiversity '
                           '<http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\n'
                           'written by "Bobmath" and "LRQ3000".\n'
                           '\n'
                           'The code of wikiversity is here consolidated into a nice API with exceptions '
                           'handling.\n'
                           'The algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\n'
                           'v the number of erasures and nsym = n-k = the number of ECC (error correction code) '
                           'symbols.\n'
                           'This means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n'
                           '(errors where you know the position), and a combination of both errors and erasures.\n'
                           'The code should work on pretty much any reasonable version of python (2.4-3.5),\n'
                           "but I'm only testing on 2.7 - 3.4.\n"
                           '\n'
                           '.. note::\n'
                           '   The codec is universal, meaning that it can decode any message encoded by another '
                           'RS encoder\n'
                           '   as long as you provide the correct parameters.\n'
                           '   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will '
                           'be slower, first because\n'
                           "   we cannot then use the optimized bytearray() structure but only array.array('i', "
                           '...), and also because\n'
                           "   Reed-Solomon's complexity is quadratic (both in encoding and decoding), so this "
                           'means that the longer\n'
                           '   your messages, the longer it will take to encode/decode (quadratically!).\n'
                           '\n'
                           '   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the '
                           'ECC symbols,\n'
                           '   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message '
                           'length and the maximum\n'
                           '   value for one character is constrained by the same mathematical reason). By '
                           'default, we use the field GF(2^8),\n'
                           '   which means that you are limited to values between 0 and 255 (perfect to represent '
                           'a single hexadecimal\n'
                           '   symbol on computers, so you can encode any binary stream) and limited to '
                           'messages+ecc of maximum\n'
                           '   length 255. However, you can "chunk" longer messages to fit them into the message '
                           'length limit.\n'
                           '   The ``RSCodec`` class will automatically apply chunking, by splitting longer '
                           'messages into chunks and\n'
                           "   encode/decode them separately; it shouldn't make a difference from an API "
                           'perspective (ie, from your POV).\n'
                           '\n'
                           '::\n'
                           '\n'
                           '    # Initialization\n'
                           '    >>> from reedsolo import RSCodec\n'
                           '    >>> rsc = RSCodec(10)  # 10 ecc symbols\n'
                           '\n'
                           '    # Encoding\n'
                           '    >>> rsc.encode([1,2,3,4])\n'
                           "    b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M'\n"
                           '    >>> rsc.encode(bytearray([1,2,3,4]))\n'
                           "    bytearray(b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M')\n"
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa'\n"
                           '    # Note that chunking is supported transparently to encode any string length.\n'
                           '\n'
                           '    # Decoding (repairing)\n'
                           "    >>> rsc.decode(b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa')[0]\n"
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 3 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 5 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa')[0]        # 6 "
                           'errors - fail\n'
                           '    Traceback (most recent call last):\n'
                           '      ...\n'
                           '    ReedSolomonError: Could not locate error\n'
                           '\n'
                           '    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 '
                           'erasures)\n'
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2='\n"
                           "    >>> rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')[0]         # 6 "
                           'errors - ok\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=', erase_pos=[3, 4, 5, "
                           '6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n'
                           "    b'hello world'\n"
                           '\n'
                           '    # Checking\n'
                           "    >> rsc.check(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    [False]\n'
                           "    >> rmes, rmesecc = rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    # To use longer chunks or bigger values than 255 (may be very slow)\n'
                           '    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n'
                           '    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n'
                           "    >> mes = 'a' * (4095-12)\n"
                           '    >> mesecc = rsc.encode(mes)\n'
                           '    >> mesecc[2] = 1\n'
                           '    >> mesecc[-1] = 1\n'
                           '    >> rmes, rmesecc = rsc.decode(mesecc)\n'
                           '    >> rsc.check(mesecc)\n'
                           '    [False]\n'
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    If you want full control, you can skip the API and directly use the library as-is. '
                           "Here's how:\n"
                           '\n'
                           '    First you need to init the precomputed tables:\n'
                           '    >> import reedsolo as rs\n'
                           '    >> rs.init_tables(0x11d)\n'
                           '    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please '
                           'check that your prime polynomial is correct for your field.\n'
                           '    Pro tip2: by default, you can only encode messages of max length and max symbol '
                           'value = 256. If you want to encode bigger messages,\n'
                           '    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 '
                           '= max length 2^12 = 4096):\n'
                           '    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n'
                           '    >> rs.init_tables(c_exp=12, prim=prim)\n'
                           '    \n'
                           "    Let's define our RS message and ecc size:\n"
                           '    >> n = 255  # length of total message+ecc\n'
                           '    >> nsym = 12  # length of ecc\n'
                           '    >> mes = "a" * (n-nsym)  # generate a sample message\n'
                           '\n'
                           '    To optimize, you can precompute the generator polynomial:\n'
                           '    >> gen = rs.rs_generator_poly_all(n)\n'
                           '\n'
                           '    Then to encode:\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n'
                           '\n'
                           "    Let's tamper our message:\n"
                           '    >> mesecc[1] = 0\n'
                           '\n'
                           '    To decode:\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n'
                           '    Note that both the message and the ecc are corrected (if possible of course).\n'
                           '    Pro tip: if you know a few erasures positions, you can specify them in a list '
                           '`erase_pos` to double the repair power. But you can also just specify an empty list.\n'
                           '\n'
                           '    If the decoding fails, it will normally automatically check and raise a '
                           'ReedSolomonError exception that you can handle.\n'
                           '    However if you want to manually check if the repaired message is correct, you can '
                           'do so:\n'
                           '    >> rs.rs_check(rmes + recc, nsym)\n'
                           '\n'
                           '    Note: if you want to use multiple reedsolomon with different parameters, you need '
                           'to backup the globals and restore them before calling reedsolo functions:\n'
                           '    >> rs.init_tables()\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n'
                           '    Then at anytime, you can do:\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym)\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n'
                           '    The globals backup is not necessary if you use RSCodec, it will be automatically '
                           'managed.\n'
                           '\n'
                           "    Read the sourcecode's comments for more info about how it works, and for the "
                           'various parameters you can setup if\n'
                           '    you need to interface with other RS codecs.\n'
                           '\n'
                           "'''\n"
                           '\n'
                           '# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials '
                           'inside lists throughout the code and functions (because for now there are a lot of '
                           'list reversing in order to make it work, you never know the order of a polynomial, ie, '
                           'if the first coefficient is the major degree or the constant term...).\n'
                           '\n'
                           'import itertools\n'
                           'import math\n'
                           '\n'
                           '\n'
                           '################### INIT and stuff ###################\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    bytearray\n'
                           '    _bytearray = bytearray\n'
                           'except NameError:  # pragma: no cover\n'
                           '    from array import array\n'
                           '    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n'
                           "        '''Simple bytearray replacement'''\n"
                           '        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '        if isinstance(obj, str):\n'
                           '            obj = [ord(ch) for ch in obj.encode(encoding)]\n'
                           '        elif isinstance(obj, int):\n'
                           '            obj = [0] * obj\n'
                           '        return array("B", obj)\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    # compatibility with Python 2.7\n'
                           '    xrange\n'
                           'except NameError:  # pragma: no cover\n'
                           '    # compatibility with Python 3+\n'
                           '    xrange = range\n'
                           '\n'
                           'class ReedSolomonError(Exception):\n'
                           '    pass\n'
                           '\n'
                           'gf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that '
                           'a simple multiplication of two numbers can be resolved without calling % 255. For more '
                           'infos on how to generate this extended exponentiation table, see paper: "Fast software '
                           'implementation of finite field operations", Cheng Huang and Lihao Xu, Washington '
                           'University in St. Louis, Tech. Rep (2003).\n'
                           'gf_log = _bytearray(256)\n'
                           'field_charac = int(2**8 - 1)\n'
                           '\n'
                           '################### GALOIS FIELD ELEMENTS MATHS ###################\n'
                           '\n'
                           'def rwh_primes1(n):\n'
                           '    # '
                           'http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n'
                           "    ''' Returns  a list of primes < n '''\n"
                           '    sieve = [True] * int(n/2)\n'
                           '    for i in xrange(3,int(n**0.5)+1,2):\n'
                           '        if sieve[int(i/2)]:\n'
                           '            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n'
                           '    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n'
                           '\n'
                           'def find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n'
                           "    '''Compute the list of prime polynomials for the given generator and galois field "
                           "characteristic exponent.'''\n"
                           '    # fast_primes will output less results but will be significantly faster.\n'
                           '    # single will output the first prime polynomial found, so if all you want is to '
                           'just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just '
                           'use that.\n'
                           '\n'
                           '    # A prime polynomial (necessarily irreducible) is necessary to reduce the '
                           'multiplications in the Galois Field, so as to avoid overflows.\n'
                           '    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for '
                           'GF(2^8) for example)? Because we need the values to be unique.\n'
                           '    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), '
                           'then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field '
                           'it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be '
                           'doubled (ie, next power of 2), which will give 256. Then we must reduce, because we '
                           'have overflowed above the maximum value of 255. But, if we modulo 255, this will '
                           'generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. '
                           "This is very bad, as it's then not anymore a bijection (ie, a non-zero value doesn't "
                           "have a unique index). That's why we can't just modulo 255, but we need another number "
                           'above 255, which is called the prime polynomial.\n'
                           '    # Why so much hassle? Because we are using precomputed look-up tables for '
                           'multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and '
                           'alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our '
                           'result. But just like in our original field we had 0,1,2,...,p-1 distinct unique '
                           'values, in our "LUT" field using alpha we must have unique distinct values (we don\'t '
                           'care that they are different from the original field as long as they are unique and '
                           "distinct). That's why we need to avoid duplicated values, and to avoid duplicated "
                           'values we need to use a prime irreducible polynomial.\n'
                           '\n'
                           '    # Here is implemented a bruteforce approach to find all these prime polynomials, '
                           'by generating every possible prime polynomials (ie, every integers between '
                           'field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we '
                           'reject the candidate prime polynomial if it duplicates even one value or if it '
                           'generates a value above field_charac (ie, cause an overflow).\n'
                           '    # Note that this algorithm is slow if the field is too big (above 12), because '
                           "it's an exhaustive search algorithm. There are probabilistic approaches, and almost "
                           'surely prime approaches, but there is no determistic polynomial time algorithm to find '
                           'irreducible monic polynomials. More info can be found at: '
                           'http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n'
                           '    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. '
                           'Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the '
                           'eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n'
                           '\n'
                           '    # Prepare the finite field characteristic (2^p - 1), this also represent the '
                           'maximum possible value in this field\n'
                           "    root_charac = 2 # we're in GF(2)\n"
                           '    field_charac = int(root_charac**c_exp - 1)\n'
                           '    field_charac_next = int(root_charac**(c_exp+1) - 1)\n'
                           '\n'
                           '    prim_candidates = []\n'
                           '    if fast_primes:\n'
                           '        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime '
                           'polynomials and check later if they really are irreducible\n'
                           '        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter '
                           'out too small primes\n'
                           '    else:\n'
                           '        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try '
                           'each possible prime polynomial, but skip even numbers (because divisible by 2 so '
                           'necessarily not irreducible)\n'
                           '\n'
                           '    # Start of the main loop\n'
                           '    correct_primes = []\n'
                           '    for prim in prim_candidates: # try potential candidates primitive irreducible '
                           'polys\n'
                           '        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was '
                           'already generated in the field (value at index x is set to 1) or not (set to 0 by '
                           'default)\n'
                           '        conflict = False # flag to know if there was at least one conflict\n'
                           '\n'
                           '        # Second loop, build the whole Galois Field\n'
                           '        x = 1\n'
                           '        for i in xrange(field_charac):\n'
                           '            # Compute the next value in the field (ie, the next power of '
                           'alpha/generator)\n'
                           '            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '            # Rejection criterion: if the value overflowed (above field_charac) or is '
                           'a duplicate of a previously generated power of alpha, then we reject this polynomial '
                           '(not prime)\n'
                           '            if x > field_charac or seen[x] == 1:\n'
                           '                conflict = True\n'
                           '                break\n'
                           '            # Else we flag this value as seen (to maybe detect future duplicates), and '
                           'we continue onto the next power of alpha\n'
                           '            else:\n'
                           '                seen[x] = 1\n'
                           '\n'
                           "        # End of the second loop: if there's no conflict (no overflow nor duplicated "
                           'value), this is a prime polynomial!\n'
                           '        if not conflict: \n'
                           '            correct_primes.append(prim)\n'
                           '            if single: return prim\n'
                           '\n'
                           '    # Return the list of all prime polynomials\n'
                           '    return correct_primes # you can use the following to print the hexadecimal '
                           'representation of each prime polynomial: print [hex(i) for i in correct_primes]\n'
                           '\n'
                           'def init_tables(prim=0x11d, generator=2, c_exp=8):\n'
                           "    '''Precompute the logarithm and anti-log tables for faster computation later, "
                           'using the provided primitive polynomial.\n'
                           '    These tables are used for multiplication/division since addition/substraction are '
                           'simple XOR operations inside GF of characteristic 2.\n'
                           '    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any '
                           'number b (the base or generator of the logarithm), then we can use any number b to '
                           'precompute logarithm and anti-log (exponentiation) tables to use for multiplying two '
                           'numbers x and y.\n'
                           "    That's why when we use a different base/generator number, the log and anti-log "
                           'tables are drastically different, but the resulting computations are the same given '
                           'any such tables.\n'
                           '    For more infos, see '
                           'https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n'
                           "    '''\n"
                           '    # generator is the generator number (the "increment" that will be used to walk '
                           'through the field by multiplication, this must be a prime number). This is basically '
                           'the base of the logarithm/anti-log tables. Also often noted "alpha" in academic '
                           'books.\n'
                           '    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it '
                           "can't represented as the product of two smaller polynomials). It's a polynomial in the "
                           "binary sense: each bit is a coefficient, but in fact it's an integer between "
                           'field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial '
                           'will be used to reduce the overflows back into the range of the Galois Field without '
                           'duplicating values (all values should be unique). See the function find_prime_polys() '
                           'and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n'
                           "    # note that the choice of generator or prime polynomial doesn't matter very much: "
                           'any two finite fields of size p^n have identical structure, even if they give the '
                           'individual elements different names (ie, the coefficients of the codeword will be '
                           'different, but the final result will be the same: you can always correct as many '
                           "errors/erasures with any choice for those parameters). That's why it makes sense to "
                           'refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as '
                           'one concept: GF(p^n). It can however impact sensibly the speed (because some '
                           'parameters will generate sparser tables).\n'
                           "    # c_exp is the exponent for the field's characteristic GF(2^c_exp)\n"
                           '\n'
                           '    # Redefine _bytearray() in case we need to support integers or messages of length '
                           '> 256\n'
                           '    global _bytearray\n'
                           '    if c_exp <= 8:\n'
                           '        _bytearray = bytearray\n'
                           '    else:\n'
                           '        from array import array\n'
                           '        def _bytearray(obj = 0, encoding = "latin-1"):\n'
                           "            '''Fake bytearray replacement, supporting int values above 255'''\n"
                           '            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '            if isinstance(obj, str):  # obj is a string, convert to list of ints\n'
                           '                obj = obj.encode(encoding)\n'
                           '                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n'
                           '                    obj = [ord(chr) for chr in obj]\n'
                           '                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need '
                           "to convert to int for array.array('i', obj)\n"
                           '                    obj = [int(chr) for chr in obj]\n'
                           '                else:\n'
                           '                    raise(ValueError, "Type of object not recognized!")\n'
                           '            elif isinstance(obj, int):  # compatibility with list preallocation '
                           'bytearray(int)\n'
                           '                obj = [0] * obj\n'
                           '            elif isinstance(obj, bytes):\n'
                           '                obj = [int(b) for b in obj]\n'
                           "            # Else obj is a list of int, it's ok\n"
                           '            return array("i", obj)\n'
                           '\n'
                           '    # Init global tables\n'
                           '    global gf_exp, gf_log, field_charac\n'
                           '    field_charac = int(2**c_exp - 1)\n'
                           '    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first '
                           'two elements will always be [GF256int(1), generator]\n'
                           '    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus '
                           'unused\n'
                           '\n'
                           '    # For each possible value in the galois field 2^8, we will pre-compute the '
                           'logarithm and anti-logarithm (exponential) of this value\n'
                           '    # To do that, we generate the Galois Field F(2^p) by building a list starting with '
                           'the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, '
                           'α^2, ..., α^(p-1).\n'
                           '    x = 1\n'
                           '    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 '
                           'because of modulo: g^255==g^0 but either way, this does not change the later outputs '
                           '(ie, the ecc symbols will be the same either way)\n'
                           '        gf_exp[i] = x # compute anti-log for this value and store it in a table\n'
                           '        gf_log[x] = i # compute log at the same time\n'
                           '        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '        # If you use only generator==2 or a power of 2, you can use the following '
                           'which is faster than gf_mult_noLUT():\n'
                           '        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power '
                           'of 2^y)\n'
                           '        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n'
                           '            #x ^= prim # substract the primary polynomial to the current value '
                           '(instead of 255, so that we get a unique set made of coprime numbers), this is the '
                           'core of the tables generation\n'
                           '\n'
                           "    # Optimization: double the size of the anti-log table so that we don't need to mod "
                           '255 to stay inside the bounds (because we will mainly use this table for the '
                           'multiplication of two GF numbers, no more).\n'
                           '    for i in xrange(field_charac, field_charac * 2):\n'
                           '        gf_exp[i] = gf_exp[i - field_charac]\n'
                           '\n'
                           '    return [gf_log, gf_exp, field_charac]\n'
                           '\n'
                           'def gf_add(x, y):\n'
                           '    return x ^ y\n'
                           '\n'
                           'def gf_sub(x, y):\n'
                           '    return x ^ y # in binary galois field, substraction is just the same as addition '
                           '(since we mod 2)\n'
                           '\n'
                           'def gf_neg(x):\n'
                           '    return x\n'
                           '\n'
                           'def gf_inverse(x):\n'
                           '    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n'
                           '\n'
                           'def gf_mul(x, y):\n'
                           '    if x == 0 or y == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_div(x, y):\n'
                           '    if y == 0:\n'
                           '        raise ZeroDivisionError()\n'
                           '    if x == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_pow(x, power):\n'
                           '    return gf_exp[(gf_log[x] * power) % field_charac]\n'
                           '\n'
                           'def gf_mult_noLUT_slow(x, y, prim=0):\n'
                           "    '''Multiplication in Galois Fields without using a precomputed look-up table (and "
                           "thus it's slower) by using the standard carry-less multiplication + modular reduction "
                           "using an irreducible prime polynomial.'''\n"
                           '\n'
                           '    ### Define bitwise carry-less operations as inner functions ###\n'
                           '    def cl_mult(x,y):\n'
                           "        '''Bitwise carry-less multiplication on integers'''\n"
                           '        z = 0\n'
                           '        i = 0\n'
                           '        while (y>>i) > 0:\n'
                           '            if y & (1<<i):\n'
                           '                z ^= x<<i\n'
                           '            i += 1\n'
                           '        return z\n'
                           '\n'
                           '    def bit_length(n):\n'
                           "        '''Compute the position of the most significant bit (1) of an integer. "
                           "Equivalent to int.bit_length()'''\n"
                           '        bits = 0\n'
                           '        while n >> bits: bits += 1\n'
                           '        return bits\n'
                           ' \n'
                           '    def cl_div(dividend, divisor=None):\n'
                           "        '''Bitwise carry-less long division on integers and returns the remainder'''\n"
                           '        # Compute the position of the most significant bit for each integers\n'
                           '        dl1 = bit_length(dividend)\n'
                           '        dl2 = bit_length(divisor)\n'
                           '        # If the dividend is smaller than the divisor, just exit\n'
                           '        if dl1 < dl2:\n'
                           '            return dividend\n'
                           '        # Else, align the most significant 1 of the divisor to the most significant 1 '
                           'of the dividend (by shifting the divisor)\n'
                           '        for i in xrange(dl1-dl2,-1,-1):\n'
                           '            # Check that the dividend is divisible (useless for the first iteration '
                           'but important for the next ones)\n'
                           '            if dividend & (1 << i+dl2-1):\n'
                           '                # If divisible, then shift the divisor to align the most significant '
                           'bits and XOR (carry-less substraction)\n'
                           '                dividend ^= divisor << i\n'
                           '        return dividend\n'
                           ' \n'
                           '    ### Main GF multiplication routine ###\n'
                           ' \n'
                           '    # Multiply the gf numbers\n'
                           '    result = cl_mult(x,y)\n'
                           '    # Then do a modular reduction (ie, remainder from the division) with an '
                           'irreducible primitive polynomial so that it stays inside GF bounds\n'
                           '    if prim > 0:\n'
                           '        result = cl_div(result, prim)\n'
                           ' \n'
                           '    return result\n'
                           '\n'
                           'def gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n'
                           "    '''Galois Field integer multiplication using Russian Peasant Multiplication "
                           'algorithm (faster than the standard multiplication + modular reduction).\n'
                           '    If prim is 0 and carryless=False, then the function produces the result for a '
                           'standard integers multiplication (no carry-less arithmetics nor modular '
                           "reduction).'''\n"
                           '    r = 0\n'
                           '    while y: # while y is above 0\n'
                           '        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the '
                           "corresponding x to r (the sum of all x's corresponding to odd y's will give the final "
                           "product). Note that since we're in GF(2), the addition is in fact an XOR (very "
                           'important because in GF(2) the multiplication and additions are carry-less, thus it '
                           'changes the result!).\n'
                           '        y = y >> 1 # equivalent to y // 2\n'
                           '        x = x << 1 # equivalent to x*2\n'
                           '        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 '
                           'then apply modular reduction using the primitive polynomial (we just substract, but '
                           'since the primitive number can be above 256 then we directly XOR).\n'
                           '\n'
                           '    return r\n'
                           '\n'
                           '\n'
                           '################### GALOIS FIELD POLYNOMIALS MATHS ###################\n'
                           '\n'
                           'def gf_poly_scale(p, x):\n'
                           '    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n'
                           '\n'
                           'def gf_poly_add(p, q):\n'
                           '    r = _bytearray( max(len(p), len(q)) )\n'
                           '    r[len(r)-len(p):len(r)] = p\n'
                           '    #for i in xrange(len(p)):\n'
                           '        #r[i + len(r) - len(p)] = p[i]\n'
                           '    for i in xrange(len(q)):\n'
                           '        r[i + len(r) - len(q)] ^= q[i]\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul(p, q):\n'
                           "    '''Multiply two polynomials, inside Galois Field (but the procedure is generic). "
                           "Optimized function by precomputation of log.'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Precompute the logarithm of p\n'
                           '    lp = [gf_log[p[i]] for i in xrange(len(p))]\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        qj = q[j] # optimization: load the coefficient once\n'
                           '        if qj != 0: # log(0) is undefined, we need to check that\n'
                           '            lq = gf_log[qj] # Optimization: precache the logarithm of the current '
                           'coefficient of q\n'
                           '            for i in xrange(len(p)):\n'
                           '                if p[i] != 0: # log(0) is undefined, need to check that...\n'
                           '                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = '
                           'gf_add(r[i+j], gf_mul(p[i], q[j]))\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials '
                           "without precomputation, but thus it's slower\n"
                           "    '''Multiply two polynomials, inside Galois Field'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        for i in xrange(len(p)):\n'
                           '            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], '
                           "gf_mul(p[i], q[j])) -- you can see it's your usual polynomial multiplication\n"
                           '    return r\n'
                           '\n'
                           'def gf_poly_neg(poly):\n'
                           "    '''Returns the polynomial with all coefficients negated. In GF(2^p), negation does "
                           "not change the coefficient, so we return the polynomial as-is.'''\n"
                           '    return poly\n'
                           '\n'
                           'def gf_poly_div(dividend, divisor):\n'
                           "    '''Fast polynomial division by using Extended Synthetic Division and optimized for "
                           "GF(2^p) computations (doesn't work with standard polynomials outside of this galois "
                           "field).'''\n"
                           '    # CAUTION: this function expects polynomials to follow the opposite convention at '
                           'decoding: the terms must go from the biggest to lowest degree (while most other '
                           'functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, '
                           '2, 1], NOT [1, 2, 5]\n'
                           '\n'
                           '    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the '
                           'ecc bytes will be computed\n'
                           '    #normalizer = divisor[0] # precomputing for performance\n'
                           '    for i in xrange(len(dividend) - (len(divisor)-1)):\n'
                           '        #msg_out[i] /= normalizer # for general polynomial division (when polynomials '
                           'are non-monic), the usual way of using synthetic division is to divide the divisor '
                           'g(x) with its leading coefficient (call it a). In this implementation, this means:we '
                           'need to compute: coef = msg_out[i] / gen[0]. For more infos, see '
                           'http://en.wikipedia.org/wiki/Synthetic_division\n'
                           '        coef = msg_out[i] # precaching\n'
                           '        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly '
                           "(and it's also a good optimization). In fact if you remove it, it should still work "
                           "because gf_mul() will take care of the condition. But it's still a good practice to "
                           'put the condition here.\n'
                           '            for j in xrange(1, len(divisor)): # in synthetic division, we always skip '
                           "the first coefficient of the divisior, because it's only used to normalize the "
                           'dividend coefficient\n'
                           '                if divisor[j] != 0: # log(0) is undefined\n'
                           '                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the '
                           'more mathematically correct (but xoring directly is faster): msg_out[i + j] += '
                           '-divisor[j] * coef\n'
                           '\n'
                           '    # The resulting msg_out contains both the quotient and the remainder, the '
                           'remainder being the size of the divisor (the remainder has necessarily the same degree '
                           "as the divisor -- not length but degree == length-1 -- since it's what we couldn't "
                           'divide from the dividend), so we compute the index where this separation is, and '
                           'return the quotient and remainder.\n'
                           '    separator = -(len(divisor)-1)\n'
                           '    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n'
                           '\n'
                           'def gf_poly_square(poly):  # pragma: no cover\n'
                           "    '''Linear time implementation of polynomial squaring. For details, see paper: "
                           '"A fast software implementation for arithmetic operations in GF (2n)". De Win, E., '
                           'Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In '
                           "Advances in Cryptology - Asiacrypt'96 (pp. 65-76). Springer Berlin Heidelberg.'''\n"
                           '    length = len(poly)\n'
                           '    out = _bytearray(2*length - 1)\n'
                           '    for i in xrange(length-1):\n'
                           '        p = poly[i]\n'
                           '        k = 2*i\n'
                           '        if p != 0:\n'
                           '            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo '
                           '(2^r)-1 since gf_exp is duplicated up to 510.\n'
                           '            out[k] = gf_exp[2*gf_log[p]]\n'
                           '        #else: # not necessary since the output is already initialized to an array of '
                           '0\n'
                           '            #out[k] = 0\n'
                           '    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n'
                           '    if out[0] == 0: out[0] = 2*poly[1] - 1\n'
                           '    return out\n'
                           '\n'
                           'def gf_poly_eval(poly, x):\n'
                           "    '''Evaluates a polynomial in GF(2^p) given the value for x. This is based on "
                           "Horner's scheme for maximum efficiency.'''\n"
                           '    y = poly[0]\n'
                           '    for i in xrange(1, len(poly)):\n'
                           '        y = gf_mul(y, x) ^ poly[i]\n'
                           '    return y\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON ENCODING ###################\n'
                           '\n'
                           'def rs_generator_poly(nsym, fcr=0, generator=2):\n'
                           "    '''Generate an irreducible generator polynomial (necessary to encode a message "
                           "into Reed-Solomon)'''\n"
                           '    g = _bytearray([1])\n'
                           '    for i in xrange(nsym):\n'
                           '        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n'
                           '    return g\n'
                           '\n'
                           'def rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n'
                           "    '''Generate all irreducible generator polynomials up to max_nsym (usually you can "
                           'use n, the length of the message+ecc). Very useful to reduce processing time if you '
                           "want to encode using variable schemes and nsym rates.'''\n"
                           '    g_all = {}\n'
                           '    g_all[0] = g_all[1] = _bytearray([1])\n'
                           '    for nsym in xrange(max_nsym):\n'
                           '        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n'
                           '    return g_all\n'
                           '\n'
                           'def rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Simple Reed-Solomon encoding (mainly an example for you to understand how it "
                           "works, because it's slower than the inlined function below)'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    # Pad the message, then divide it by the irreducible generator polynomial\n'
                           '    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n'
                           '    # The remainder is our RS code! Just append it to our original message to get our '
                           'full codeword (this represents a polynomial of max 256 terms)\n'
                           '    msg_out = msg_in + remainder\n'
                           '    # Return the codeword\n'
                           '    return msg_out\n'
                           '\n'
                           'def rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Reed-Solomon main encoding function, using polynomial division (Extended "
                           'Synthetic Division, the fastest algorithm available to my knowledge), better explained '
                           "at http://research.swtch.com/field'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    msg_in = _bytearray(msg_in)\n'
                           '    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the '
                           'values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc '
                           'symbols).\n'
                           '\n'
                           '    # Precompute the logarithm of every items in the generator\n'
                           '    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n'
                           '\n'
                           '    # Extended synthetic division main loop\n'
                           '    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is '
                           'about 2x faster)\n'
                           '    for i in xrange(len(msg_in)):\n'
                           "        coef = msg_out[i] # Note that it's msg_out here, not msg_in. Thus, we reuse "
                           'the updated value at each iteration (this is how Synthetic Division works: instead of '
                           'storing in a temporary register the intermediate values, we directly commit them to '
                           'the output).\n'
                           '        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial '
                           'division (when polynomials are non-monic), the usual way of using synthetic division '
                           'is to divide the divisor g(x) with its leading coefficient (call it a). In this '
                           'implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n'
                           '        if coef != 0: # log(0) is undefined, so we need to manually check for this '
                           "case. There's no need to check the divisor here because we know it can't be 0 since we "
                           'generated it.\n'
                           '            lcoef = gf_log[coef] # precaching\n'
                           '\n'
                           '            for j in xrange(1, len(gen)): # in synthetic division, we always skip the '
                           "first coefficient of the divisior, because it's only used to normalize the dividend "
                           'coefficient (which is here useless since the divisor, the generator polynomial, is '
                           'always monic)\n'
                           '                #if gen[j] != 0: # log(0) is undefined so we need to check that, but '
                           "it slow things down in fact and it's useless in our case (reed-solomon encoding) since "
                           'we know that all coefficients in the generator are not 0\n'
                           '                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent '
                           'to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we '
                           "are in GF256, it's equivalent to an addition and to an XOR). In other words, this is "
                           'simply a "multiply-accumulate operation"\n'
                           '\n'
                           '    # Recopy the original message bytes (overwrites the part where the quotient was '
                           'computed)\n'
                           '    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is '
                           'msg_in padded with [0]*nsym\n'
                           '    return msg_out\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON DECODING ###################\n'
                           '\n'
                           'def rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Given the received codeword msg and the number of error correcting symbols "
                           '(nsym), computes the syndromes polynomial.\n'
                           "    Mathematically, it's essentially equivalent to a Fourrier Transform (Chien search "
                           'being the inverse).\n'
                           "    '''\n"
                           '    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). '
                           'This effectively shifts the syndrome, and will shift every computations depending on '
                           'the syndromes (such as the errors locator polynomial, errors evaluator polynomial, '
                           'etc. but not the errors positions).\n'
                           '    # This is not necessary as anyway syndromes are defined such as there are only '
                           'non-zero coefficients (the only 0 is the shift of the constant here) and subsequent '
                           'computations will/must account for the shift by skipping the first iteration (eg, the '
                           'often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt '
                           'every subsequent computations to start from 0 instead of 1.\n'
                           '    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n'
                           '\n'
                           'def rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list '
                           'of the positions of the errors/erasures/errata\n'
                           "    '''Forney algorithm, computes the values (error magnitude) to correct the input "
                           "message.'''\n"
                           '    global field_charac\n'
                           '    msg = _bytearray(msg_in)\n'
                           '    # calculate errata locator polynomial to correct both errors and erasures (by '
                           'combining the errors positions given by the error locator polynomial found by BM with '
                           'the erasures positions given by caller)\n'
                           '    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to '
                           'coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it '
                           'will become [len(msg)-1, len(msg)-2, len(msg) -3])\n'
                           '    err_loc = rs_find_errata_locator(coef_pos, generator)\n'
                           '    # calculate errata evaluator polynomial (often called Omega or Gamma in academic '
                           'papers)\n'
                           '    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n'
                           '\n'
                           '    # Second part of Chien search to get the error location polynomial X from the '
                           'error positions in err_pos (the roots of the error locator polynomial, ie, where it '
                           'evaluates to 0)\n'
                           '    X = [] # will store the position of the errors\n'
                           '    for i in xrange(len(coef_pos)):\n'
                           '        l = field_charac - coef_pos[i]\n'
                           '        X.append( gf_pow(generator, -l) )\n'
                           '\n'
                           '    # Forney algorithm: compute the magnitudes\n'
                           '    E = _bytearray(len(msg)) # will store the values that need to be corrected '
                           '(substracted) to the message containing errors. This is sometimes called the error '
                           'magnitude polynomial.\n'
                           '    Xlength = len(X)\n'
                           '    for i, Xi in enumerate(X):\n'
                           '\n'
                           '        Xi_inv = gf_inverse(Xi)\n'
                           '\n'
                           '        # Compute the formal derivative of the error locator polynomial (see Blahut, '
                           'Algebraic codes for data transmission, pp 196-197).\n'
                           '        # the formal derivative of the errata locator is used as the denominator of '
                           'the Forney Algorithm, which simply says that the ith error value is given by '
                           'error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See '
                           'Blahut, Algebraic codes for data transmission, pp 196-197.\n'
                           '        err_loc_prime_tmp = []\n'
                           '        for j in xrange(Xlength):\n'
                           '            if j != i:\n'
                           '                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n'
                           '        # compute the product, which is the denominator of the Forney algorithm '
                           '(errata locator derivative)\n'
                           '        err_loc_prime = 1\n'
                           '        for coef in err_loc_prime_tmp:\n'
                           '            err_loc_prime = gf_mul(err_loc_prime, coef)\n'
                           '        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, '
                           '1)\n'
                           '\n'
                           '        # Test if we could find the errata locator, else we raise an Exception '
                           '(because else since we divide y by err_loc_prime to compute the magnitude, we will get '
                           'a ZeroDivisionError exception otherwise)\n'
                           '        if err_loc_prime == 0:\n'
                           '            raise ReedSolomonError("Decoding failed: Forney algorithm could not '
                           'properly detect where the errors are located (errata locator prime is 0).")\n'
                           '\n'
                           '        # Compute y (evaluation of the errata evaluator polynomial)\n'
                           '        # This is a more faithful translation of the theoretical equation contrary to '
                           'the old forney method. Here it is exactly copy/pasted from the included presentation '
                           'decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) '
                           "(in the paper it's for j in s, but it's useless when len(X) < s because we compute "
                           'neutral terms 1 for nothing, and wrong when correcting more than s erasures or '
                           'erasures+errors since it prevents computing all required terms).\n'
                           '        # Thus here this method works with erasures too because firstly we fixed the '
                           "equation to be like the theoretical one (don't know why it was modified in "
                           "_old_forney(), if it's an optimization, it doesn't enhance anything), and secondly "
                           'because we removed the product bound on s, which prevented computing errors and '
                           'erasures above the s=(n-k)//2 bound.\n'
                           '        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm '
                           '(errata evaluator evaluated)\n'
                           '        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n'
                           '        \n'
                           '        # Compute the magnitude\n'
                           '        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, '
                           'calculated by the Forney algorithm (an equation in fact): dividing the errata '
                           'evaluator with the errata locator derivative gives us the errata magnitude (ie, value '
                           'to repair) the ith symbol\n'
                           '        E[err_pos[i]] = magnitude # store the magnitude for this error into the '
                           'magnitude polynomial\n'
                           '\n'
                           '    # Apply the correction of values to get our message corrected! (note that the ecc '
                           'bytes also gets corrected!)\n'
                           "    # (this isn't the Forney algorithm, we just apply the result of decoding here)\n"
                           '    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct '
                           'message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is '
                           "replaced by XOR since it's equivalent in GF(2^p)). So in fact here we substract from "
                           'the received message the errors magnitude, which logically corrects the value to what '
                           'it should be.\n'
                           '    return msg\n'
                           '\n'
                           'def rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n'
                           "    '''Find error/errata locator and evaluator polynomials with Berlekamp-Massey "
                           "algorithm'''\n"
                           '    # The idea is that BM will iteratively estimate the error locator polynomial.\n'
                           '    # To do this, it will compute a Discrepancy term called Delta, which will tell us '
                           'if the error locator polynomial needs an update or not\n'
                           "    # (hence why it's called discrepancy: it tells us when we are getting off board "
                           'from the correct value).\n'
                           '\n'
                           '    # Init the polynomials\n'
                           '    if erase_loc: # if the erasure locator polynomial is supplied, we init with its '
                           'value, so that we include erasures in the final locator polynomial\n'
                           '        err_loc = _bytearray(erase_loc)\n'
                           '        old_loc = _bytearray(erase_loc)\n'
                           '    else:\n'
                           '        err_loc = _bytearray([1]) # This is the main variable we want to fill, also '
                           'called Sigma in other notations or more formally the errors/errata locator '
                           'polynomial.\n'
                           '        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the '
                           'errata locator polynomial of the previous iteration in order to update other necessary '
                           'variables.\n'
                           '    #L = 0 # update flag variable, not needed here because we use an alternative '
                           'equivalent way of checking if update is needed (but using the flag could potentially '
                           'be faster depending on if using length(list) is taking linear time in your language, '
                           "here in Python it's constant so it's as fast.\n"
                           '\n'
                           '    # Fix the syndrome shifting: when computing the syndrome, some implementations may '
                           'prepend a 0 coefficient for the lowest degree term (the constant). This is a case of '
                           'syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I '
                           "don't know what purpose serves this shifting). If that's the case, then we need to "
                           'account for the syndrome shifting when we use the syndrome such as inside BM, by '
                           'skipping those prepended coefficients.\n'
                           '    # Another way to detect the shifting is to detect the 0 coefficients: by '
                           'definition, a syndrome does not contain any 0 coefficient (except if there are no '
                           "errors/erasures, in this case they are all 0). This however doesn't work with the "
                           'modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, '
                           'leaving only the coefficients corresponding to errors.\n'
                           '    synd_shift = 0\n'
                           '    if len(synd) > nsym: synd_shift = len(synd) - nsym\n'
                           '\n'
                           '    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), '
                           'except when you input a partial erase_loc and using the full syndrome instead of the '
                           'Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail '
                           'badly with IndexError).\n'
                           '        if erase_loc: # if an erasures locator polynomial was provided to init the '
                           'errors locator polynomial, then we must skip the FIRST erase_count iterations (not the '
                           'last iterations, this is very important!)\n'
                           '            K = erase_count+i+synd_shift\n'
                           "        else: # if erasures locator is not provided, then either there's no erasures "
                           "to account or we use the Forney syndromes, so we don't need to use erase_count nor "
                           'erase_loc (the erasures have been trimmed out of the Forney syndromes).\n'
                           '            K = i+synd_shift\n'
                           '\n'
                           '        # Compute the discrepancy Delta\n'
                           '        # Here is the close-to-the-books operation to compute the discrepancy Delta: '
                           "it's a simple polynomial multiplication of error locator with the syndromes, and then "
                           'we get the Kth element.\n'
                           '        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be '
                           "gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it's not "
                           'absolutely necessary to correctly decode.\n'
                           "        # But this can be optimized: since we only need the Kth element, we don't need "
                           'to compute the polynomial multiplication for any other element but the Kth. Thus to '
                           'optimize, we compute the polymul only at the item we need, skipping the rest (avoiding '
                           'a nested loop, thus we are linear time instead of quadratic).\n'
                           '        # This optimization is actually described in several figures of the book '
                           '"Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge '
                           'university press.\n'
                           '        delta = synd[K]\n'
                           '        for j in xrange(1, len(err_loc)):\n'
                           '            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called '
                           'discrepancy. Here we do a partial polynomial multiplication (ie, we compute the '
                           'polynomial multiplication only for the term of degree K). Should be equivalent to '
                           'brownanrs.polynomial.mul_at().\n'
                           '        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n'
                           '\n'
                           '        # Shift polynomials to compute the next degree\n'
                           '        old_loc = old_loc + _bytearray([0])\n'
                           '\n'
                           '        # Iteratively estimate the errata locator and evaluator polynomials\n'
                           "        if delta != 0: # Update only if there's a discrepancy\n"
                           '            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined '
                           'because rule A just says that we skip any modification for this iteration)\n'
                           '            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as '
                           'long as L is correctly computed\n'
                           '                # Computing errata locator polynomial Sigma\n'
                           '                new_loc = gf_poly_scale(old_loc, delta)\n'
                           '                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we '
                           'are doing err_loc * 1/delta = err_loc // delta\n'
                           '                err_loc = new_loc\n'
                           '                # Update the update flag\n'
                           "                #L = K - L # the update flag L is tricky: in Blahut's schema, it's "
                           'mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this '
                           'function, if you forgot to do `- erase_count` it would lead to correcting only '
                           '2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this '
                           'latest draft, this will lead to a wrong decoding in some cases where it should '
                           'correctly decode! Thus you should try with and without `- erase_count` to update L on '
                           'your own implementation and see which one works OK without producing wrong decoding '
                           'failures.\n'
                           '\n'
                           '            # Update with the discrepancy\n'
                           '            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n'
                           '\n'
                           "    # Check if the result is correct, that there's not too many errors to correct\n"
                           '    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, '
                           'else errs will not be of the correct size\n'
                           '    errs = len(err_loc) - 1\n'
                           '    if (errs-erase_count) * 2 + erase_count > nsym:\n'
                           '        raise ReedSolomonError("Too many errors to correct")\n'
                           '\n'
                           '    return err_loc\n'
                           '\n'
                           'def rs_find_errata_locator(e_pos, generator=2):\n'
                           "    '''Compute the erasures/errors/errata locator polynomial from the "
                           'erasures/errors/errata positions (the positions must be relative to the x coefficient, '
                           'eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being '
                           'the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients '
                           'are reversed since the ecc characters are placed as the first coefficients of the '
                           'polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] '
                           "= erasures_loc to be specified as an argument.'''\n"
                           '    # See: '
                           'http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf '
                           'and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of '
                           'Research and development 23.3 (1979): 299-315. '
                           'http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and '
                           'also a MatLab implementation here: '
                           'http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n'
                           '    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the '
                           'multiplication starts correctly without nulling any term\n'
                           '    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for '
                           'i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in '
                           "this library it's gf(3)). To generate c*x where c is a constant, we simply generate a "
                           'Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient '
                           'for x^1.\n'
                           '    for i in e_pos:\n'
                           '        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, '
                           'i), 0]) )\n'
                           '    return e_loc\n'
                           '\n'
                           'def rs_find_error_evaluator(synd, err_loc, nsym):\n'
                           "    '''Compute the error (or erasures if you supply sigma=erasures locator polynomial, "
                           'or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata '
                           'locator Sigma. Omega is already computed at the same time as Sigma inside the '
                           'Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute '
                           'Omega afterwards using this method, or just ensure that Omega computed by BM is '
                           "correct given Sigma.'''\n"
                           '    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n'
                           '    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # '
                           'first multiply syndromes * errata_locator, then do a polynomial division to truncate '
                           'the polynomial to the required length\n'
                           '\n'
                           '    # Faster way that is equivalent\n'
                           '    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the '
                           'errata locator polynomial\n'
                           '    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of '
                           'the length we want, which is equivalent to slicing the list (which represents the '
                           'polynomial)\n'
                           '\n'
                           '    return remainder\n'
                           '\n'
                           'def rs_find_errors(err_loc, nmess, generator=2):\n'
                           "    '''Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce "
                           "trial, this is a sort of Chien's search (but less efficient, Chien's search is a way "
                           "to evaluate the polynomial such that each evaluation only takes constant time).'''\n"
                           '    # nmess = length of whole codeword (message + ecc symbols)\n'
                           '    errs = len(err_loc) - 1\n'
                           '    err_pos = []\n'
                           '    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here '
                           'we optimize to just check the interesting symbols\n'
                           "        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It's a 0? Bingo, it's a "
                           'root of the error locator polynomial, in other terms this is the location of an error\n'
                           '            err_pos.append(nmess - 1 - i)\n'
                           '    # Sanity check: the number of errors/errata positions found should be exactly the '
                           'same as the length of the errata locator polynomial\n'
                           '    if len(err_pos) != errs:\n'
                           '        # TODO: to decode messages+ecc with length n > 255, we may try to use a '
                           'bruteforce approach: the correct positions ARE in the final array j, but the problem '
                           "is because we are above the Galois Field's range, there is a wraparound so that for "
                           'example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because '
                           "258 % 255 == 3, same for the other values), so we can't discriminate. The issue is "
                           'that fixing any errs_nb errors among those will always give a correct output message '
                           '(in the sense that the syndrome will be all 0), so we may not even be able to check if '
                           "that's correct or not, so I'm not sure the bruteforce approach may even be possible.\n"
                           '        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the '
                           'errata locator polynomial!")\n'
                           '    return err_pos\n'
                           '\n'
                           'def rs_forney_syndromes(synd, pos, nmess, generator=2):\n'
                           '    # Compute Forney syndromes, which computes a modified syndromes to compute only '
                           'errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which '
                           'allows to correct the message based on the location of errors.\n'
                           '    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree '
                           'positions (instead of the erasures positions)\n'
                           '\n'
                           '    # Optimized method, all operations are inlined\n'
                           '    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is '
                           'always 0 by definition\n'
                           '    for i in xrange(len(pos)):\n'
                           '        x = gf_pow(generator, erase_pos_reversed[i])\n'
                           '        for j in xrange(len(fsynd) - 1):\n'
                           '            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n'
                           "        #fsynd.pop() # useless? it doesn't change the results of computations to leave "
                           'it there\n'
                           '\n'
                           '    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * '
                           'synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as '
                           'many books do not even mention it (and it works without trimming)\n'
                           '    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A '
                           'single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, '
                           "IEEE International Conference on ICASSP'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n"
                           '    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # '
                           'computing the erasures locator polynomial\n'
                           '    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome '
                           'to get the untrimmed forney syndrome\n'
                           '    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are '
                           'useless. Seems to be not necessary, but this reduces the computation time later in BM '
                           "(thus it's an optimization).\n"
                           '\n'
                           '    return fsynd\n'
                           '\n'
                           'def rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        # Note that it is in fact possible to encode/decode messages that are longer '
                           'than field_charac, but because this will be above the field, this will generate more '
                           'error positions during Chien Search than it should, because this will generate '
                           "duplicate values, which should normally be prevented thank's to the prime polynomial "
                           "reduction (eg, because it can't discriminate between error at position 1 or 256, both "
                           "being exactly equal under galois field 2^8). So it's really not advised to do it, but "
                           "it's possible (but then you're not guaranted to be able to correct any error/erasure "
                           'on symbols with a position above the length of field_charac -- if you really need a '
                           'bigger message without chunking, then you should better enlarge c_exp so that you get '
                           'a bigger field).\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures to correct (beyond the Singleton bound)\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n'
                           '\n'
                           '    # Find errors locations\n'
                           '    if only_erasures:\n'
                           '        err_pos = []\n'
                           '    else:\n'
                           '        # compute the Forney syndromes, which hide the erasures from the original '
                           'syndrome (so that BM will just have to deal with errors, not erasures)\n'
                           '        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n'
                           '        # compute the error locator polynomial using Berlekamp-Massey\n'
                           '        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n'
                           '        # locate the message errors using Chien search (or bruteforce search)\n'
                           '        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n'
                           '        if err_pos is None:\n'
                           '            raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # Find errors values and apply them to correct the message\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # '
                           'note that we here use the original syndrome, not the forney syndrome (because we will '
                           'correct both errors and erasures, so we need the full syndrome)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function, without using the modified Forney "
                           "syndromes'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n'
                           '\n'
                           '    # prepare erasures locator and evaluator polynomials\n'
                           '    erase_loc = None\n'
                           '    #erase_eval = None\n'
                           '    erase_count = 0\n'
                           '    if erase_pos:\n'
                           '        erase_count = len(erase_pos)\n'
                           '        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n'
                           '        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n'
                           '        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, '
                           'len(erase_loc)-1)\n'
                           '\n'
                           '    # prepare errors/errata locator polynomial\n'
                           '    if only_erasures:\n'
                           '        err_loc = erase_loc[::-1]\n'
                           '        #err_eval = erase_eval[::-1]\n'
                           '    else:\n'
                           '        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, '
                           'erase_count=erase_count)\n'
                           '        err_loc = err_loc[::-1]\n'
                           '        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], '
                           'len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary '
                           'since we already compute it at the same time as the error locator poly in BM)\n'
                           '\n'
                           '    # locate the message errors\n'
                           '    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the '
                           'errata locator polynomial (ie: the positions of the errors/errata)\n'
                           '    if err_pos is None:\n'
                           '        raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_check(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Returns true if the message + ecc has no error of false otherwise (may not "
                           'always catch a wrong decoding or a wrong message, particularly if there are too many '
                           "errors -- above the Singleton bound --, but it usually does)'''\n"
                           '    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n'
                           '\n'
                           '\n'
                           '#===================================================================================================\n'
                           '# API\n'
                           '#===================================================================================================\n'
                           'class RSCodec(object):\n'
                           "    '''\n"
                           '    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to '
                           'encode a\n'
                           '    (byte)string to include the RS correction code, and pass such an encoded '
                           '(byte)string to\n'
                           '    ``decode`` to extract the original message (if the number of errors allows for '
                           'correct decoding).\n'
                           '    The ``nsym`` argument is the length of the correction code, and it determines the '
                           'number of\n'
                           '    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n'
                           "    '''\n"
                           "    '''\n"
                           '    Modifications by rotorgit 2/3/2015:\n'
                           '    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n'
                           '    different primitive polynomial and non-zero first consecutive root (fcr).\n'
                           '    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n'
                           '    the class; leaving them out will default for previous values (0 and\n'
                           '    0x11d)\n'
                           "    '''\n"
                           '\n'
                           '    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, '
                           'single_gen=True):\n'
                           "        '''Initialize the Reed-Solomon codec. Note that different parameters change "
                           'the internal values (the ecc symbols, look-up table values, etc) but not the output '
                           'result (whether your message can be repaired or not, there is no influence of the '
                           'parameters).\n'
                           '        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n'
                           '        nsize : maximum length of each chunk. If higher than 255, will use a higher '
                           "Galois Field, but the algorithm's complexity and computational cost will raise "
                           'quadratically...\n'
                           '        single_gen : if you want to use the same RSCodec for different nsym parameters '
                           '(but nsize the same), then set single_gen = False.\n'
                           "        '''\n"
                           '\n'
                           '        # Auto-setup if galois field or message length is different than default '
                           '(exponent 8)\n'
                           '        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois '
                           'field, we resize the galois field\n'
                           '            # Get the next closest power of two\n'
                           '            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), '
                           '2))\n'
                           '        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n'
                           '            prim = find_prime_polys(generator=generator, c_exp=c_exp, '
                           'fast_primes=True, single=True)\n'
                           '            if nsize == 255:  # resize chunk size if not set\n'
                           '                nsize = int(2**c_exp - 1)\n'
                           '        if nsym >= nsize:\n'
                           "            raise ValueError('ECC symbols must be strictly less than the total message "
                           "length (nsym < nsize).')\n"
                           '\n'
                           '        # Memorize variables\n'
                           '        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be '
                           'r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate '
                           'r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and '
                           '0.5% erasures (5 symbols out of 10).\n'
                           '        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols '
                           "after encoding, for the message alone it's nsize-nsym)\n"
                           '        self.fcr = fcr # first consecutive root, can be any value between 0 and '
                           '(2**c_exp)-1\n'
                           '        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to '
                           'find a prime poly\n'
                           '        self.generator = generator # generator integer, must be prime\n'
                           "        self.c_exp = c_exp # exponent of the field's characteristic. This both defines "
                           "the maximum value per symbol and the maximum length of one chunk. By default it's "
                           "GF(2^8), do not change if you're not sure what it means.\n"
                           '\n'
                           '        # Initialize the look-up tables for easy and quick multiplication/division\n'
                           '        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, '
                           'c_exp)\n'
                           '        # Precompute the generator polynomials\n'
                           '        if single_gen:\n'
                           '            self.gen = {}\n'
                           '            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n'
                           '        else:\n'
                           '            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n'
                           '\n'
                           '    def chunk(self, data, chunksize):\n'
                           "        '''Split a long message into chunks'''\n"
                           '        for i in xrange(0, len(data), chunksize):\n'
                           '            # Split the long message in a chunk\n'
                           '            chunk = data[i:i+chunksize]\n'
                           '            yield chunk\n'
                           '\n'
                           '    def encode(self, data, nsym=None):\n'
                           "        '''Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the "
                           "length of the message because we use chunking'''\n"
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        enc = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize - self.nsym):\n'
                           '            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, '
                           'generator=self.generator, gen=self.gen[nsym]))\n'
                           '        return enc\n'
                           '\n'
                           '    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n'
                           "        '''Repair a message, whatever its size is, by using chunking. May return a "
                           'wrong result if number of errors > nsym.\n'
                           '        Note that it returns a couple of vars: the repaired messages, and the repaired '
                           'messages+ecc (useful for checking).\n'
                           '        Usage: rmes, rmesecc = RSCodec.decode(data).\n'
                           "        '''\n"
                           '        # erase_pos is a list of positions where you know (or greatly suspect at '
                           "least) there is an erasure (ie, wrong character but you know it's at this position). "
                           'Just input the list of all positions you know there are errors, and this method will '
                           'automatically split the erasures positions to attach to the corresponding data chunk.\n'
                           '\n'
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        dec = _bytearray()\n'
                           '        dec_full = _bytearray()\n'
                           '        errata_pos_all = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            # Extract the erasures for this chunk\n'
                           '            e_pos = []\n'
                           '            if erase_pos:\n'
                           '                # First extract the erasures for this chunk (all erasures below the '
                           'maximum chunk length)\n'
                           '                e_pos = [x for x in erase_pos if x < self.nsize]\n'
                           '                # Then remove the extract erasures from the big list and also '
                           "decrement all subsequent positions values by nsize (the current chunk's size) so as to "
                           'prepare the correct alignment for the next iteration\n'
                           '                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n'
                           '            # Decode/repair this chunk!\n'
                           '            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n'
                           '            dec.extend(rmes)\n'
                           '            dec_full.extend(rmes+recc)\n'
                           '            errata_pos_all.extend(errata_pos)\n'
                           '        return dec, dec_full, errata_pos_all\n'
                           '\n'
                           '    def check(self, data, nsym=None):\n'
                           "        '''Check if a message+ecc stream is not corrupted (or fully repaired). Note: "
                           "may return a wrong result if number of errors > nsym.'''\n"
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        check = []\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            check.append(rs_check(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator))\n'
                           '        return check\n'
                           '\n'
                           '    def maxerrata(self, errors=None, erasures=None, verbose=False):\n'
                           "        '''Return the Singleton Bound for the current codec, which is the max number "
                           'of errata (errors and erasures) that the codec can decode/correct.\n'
                           '        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try '
                           'to raise an exception, but it may also not detect any problem with the message and '
                           'return 0 errors.\n'
                           '        Hence why you should use checksums if your goal is to detect errors (as '
                           'opposed to correcting them), as checksums have no bounds on the number of errors, the '
                           'only limitation being the probability of collisions.\n'
                           '        By default, return a tuple wth the maximum number of errors (2nd output) OR '
                           'erasures (2nd output) that can be corrected.\n'
                           '        If errors or erasures (not both) is specified as argument, computes the '
                           'remaining **simultaneous** correction capacity (eg, if errors specified, compute the '
                           'number of erasures that can be simultaneously corrected).\n'
                           "        Set verbose to True to get print a report.'''\n"
                           '        nsym = self.nsym\n'
                           '        # Compute the maximum number of errors OR erasures\n'
                           "        maxerrors = int(nsym/2)  # always floor the number, we can't correct half a "
                           "symbol, it's all or nothing\n"
                           '        maxerasures = nsym\n'
                           '        # Compute the maximum of simultaneous errors AND erasures\n'
                           '        if erasures is not None and erasures >= 0:\n'
                           '            # We know the erasures count, we want to know how many errors we can '
                           'correct simultaneously\n'
                           '            if erasures > maxerasures:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerrors = int((nsym-erasures)/2)\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (maxerrors, erasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return maxerrors, erasures\n'
                           '        if errors is not None and errors >= 0:\n'
                           '            # We know the errors count, we want to know how many erasures we can '
                           'correct simultaneously\n'
                           '            if errors > maxerrors:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerasures = int(nsym-(errors*2))\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (errors, maxerasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return errors, maxerasures\n'
                           '        # Return a tuple with the maximum number of errors and erasures (independently '
                           'corrected)\n'
                           '        if verbose:\n'
                           "            print('This codec can correct up to %i errors and %i erasures "
                           "independently' % (maxerrors, maxerasures))\n"
                           '        return maxerrors, maxerasures\n',
       'service': '"""ZMQ app boundary. All sockets and Engine methods belong to one thread."""\n'
                  'import queue\n'
                  'import threading\n'
                  'import time\n'
                  'import zmq\n'
                  'from .engine import Engine\n'
                  '\n'
                  '\n'
                  'class Service:\n'
                  '    def __init__(self, config, transmit, incoming=None, sensor=None, transport_tick=None):\n'
                  '        self.c=config;self.transmit=transmit;self.incoming=incoming or queue.Queue()\n'
                  '        '
                  'self.sensor=sensor;self.transport_tick=transport_tick;self.stop_event=threading.Event()\n'
                  '        self.ready=threading.Event();self.error=None;self.thread=None\n'
                  '\n'
                  '    def start(self):\n'
                  '        '
                  "self.thread=threading.Thread(target=self.run,name='radio-mac',daemon=True);self.thread.start()\n"
                  "        if not self.ready.wait(5):raise RuntimeError('Radio service did not start')\n"
                  '        if self.error:raise RuntimeError(str(self.error))\n'
                  '\n'
                  '    def stop(self):\n'
                  '        self.stop_event.set()\n'
                  '        if self.thread:self.thread.join(5)\n'
                  '\n'
                  '    def run(self):\n'
                  '        '
                  'context=zmq.Context();commands=context.socket(zmq.PULL);events=context.socket(zmq.PUSH)\n'
                  '        commands.setsockopt(zmq.MAXMSGSIZE,1024*1024)\n'
                  '        for s in (commands,events):s.setsockopt(zmq.LINGER,0)\n'
                  '        engine=None\n'
                  '        try:\n'
                  "            commands.bind('tcp://127.0.0.1:'+str(self.c['commands_port']))\n"
                  "            events.bind('tcp://127.0.0.1:'+str(self.c['events_port']))\n"
                  '            def emit(event):\n'
                  '                try:events.send_json(event,zmq.NOBLOCK)\n'
                  '                except zmq.Again:pass # Durable snapshot recovers message events on reconnect.\n'
                  '            engine=Engine(self.c,self.transmit,emit)\n'
                  '            self.ready.set()\n'
                  '            while not self.stop_event.is_set():\n'
                  '                if self.transport_tick:self.transport_tick(engine)\n'
                  '                if self.sensor:\n'
                  '                    reading=self.sensor()\n'
                  '                    if reading is not None:engine.sense(*reading)\n'
                  '                for _ in range(100):\n'
                  '                    try:engine.receive(self.incoming.get_nowait())\n'
                  '                    except queue.Empty:break\n'
                  '                for _ in range(100):\n'
                  '                    try:cmd=commands.recv_json(zmq.NOBLOCK)\n'
                  '                    except zmq.Again:break\n'
                  '                    try:\n'
                  "                        if cmd.get('cmd')=='send':engine.enqueue(cmd)\n"
                  "                        elif cmd.get('cmd')=='hello':engine.snapshot()\n"
                  "                        elif cmd.get('cmd')=='threshold':\n"
                  "                            value=float(cmd['db'])\n"
                  "                            if not -140<=value<=20:raise ValueError('Threshold outside -140..20 "
                  "dB')\n"
                  "                            engine.c['cs_threshold_db']=value\n"
                  '                    except Exception as exc:\n'
                  '                        '
                  "emit(dict(event='status',id=cmd.get('id'),status='failed',reason=str(exc)))\n"
                  '                engine.tick();self.stop_event.wait(0.003)\n'
                  '        except Exception as exc:\n'
                  "            self.error=exc;self.ready.set();print('Radio service stopped:',exc,flush=True)\n"
                  '        finally:\n'
                  '            if engine:engine.close()\n'
                  '            commands.close();events.close();context.term()\n'}
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'

      class _EmbeddedRadioLoader(_abc.MetaPathFinder, _abc.Loader):
          def find_spec(self, fullname, path=None, target=None):
              prefix = '_pixel_pulse_radio.'
              if fullname.startswith(prefix) and fullname[len(prefix):] in _RADIO_SOURCES:
                  return _util.spec_from_loader(fullname, self)
              return None

          def create_module(self, spec):
              return None

          def exec_module(self, module):
              name = module.__name__.split('.')[-1]
              module.__file__ = '<Pixel Pulse GRC>/' + name + '.py'
              exec(compile(_RADIO_SOURCES[name], module.__file__, 'exec'), module.__dict__)

      if '_pixel_pulse_radio' not in _sys.modules:
          _package = _types.ModuleType('_pixel_pulse_radio')
          _package.__path__ = []
          _package.__package__ = '_pixel_pulse_radio'
          _sys.modules['_pixel_pulse_radio'] = _package
          _sys.meta_path.insert(0, _EmbeddedRadioLoader())

      from _pixel_pulse_radio.equalizer import NLMS
      class blk(NLMS):
          def __init__(self, taps=7, mu=0.2, dd_mu=0.02, eps=1e-6):
              super().__init__(taps,mu,dd_mu,eps)
    dd_mu: radio_config["nlms_dd_mu"]
    eps: radio_config["nlms_eps"]
    mu: radio_config["nlms_mu"]
    taps: radio_config["nlms_taps"]
  states: {}
- name: epy_rs_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Inverse of rs_packet_encoder.py. Reassemble a complete PDU before CRC Check.
      A failed codeword drops the entire PDU; the existing ARQ retries the packet.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Correct each RS codeword, then emit the original encrypted frame plus CRC."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Decoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096
              self.max_coded = self.max_input + self.nsym * ((self.max_input+self.k-1)//self.k)
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.rx_count = self.fail_count = self.decoded_count = 0
              self.corrected_packets = self.corrected_bytes = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.message_port_register_out(pmt.intern('fail'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  if self.verbose:
                      print('[RS RX] DROP: expected a packed-byte PDU', flush=True)
                  return
              self.rx_count += 1
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              corrected, corrected_bits, nwords = 0, 0, 0
              try:
                  if self.enabled:
                      if not self.nsym+4 <= len(raw) <= self.max_coded:
                          raise ValueError('invalid coded packet length')
                      tail = len(raw) % 255
                      if tail and tail <= self.nsym:
                          raise ValueError('truncated final RS codeword')
                      parts = []
                      for i in range(0, len(raw), 255):
                          received_word = raw[i:i+255]
                          data, repaired_word, positions = self.rs.decode(received_word)
                          parts.append(bytes(data))
                          corrected += sum(a != b for a, b in zip(received_word, repaired_word))
                          corrected_bits += sum(bin(a ^ b).count('1') for a, b in zip(received_word, repaired_word))
                          nwords += 1
                      decoded = b''.join(parts)
                  else:
                      decoded = raw
                  if not 4 <= len(decoded) <= self.max_input:
                      raise ValueError('invalid decoded packet length')
              except (ReedSolomonError, ValueError) as exc:
                  self.fail_count += 1
                  self.message_port_pub(pmt.intern('fail'), msg)
                  if self.verbose:
                      print(f'[RS RX #{self.rx_count}] DROP: {exc}; '
                            f'RS failures={self.fail_count}; waiting for ARQ retry', flush=True)
                  return
              meta = pmt.car(msg)
              if not pmt.is_dict(meta):
                  meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bytes'), pmt.from_long(corrected))
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bits'), pmt.from_long(corrected_bits))
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(decoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(decoded), list(decoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.decoded_count += 1
              self.corrected_packets += int(corrected > 0)
              self.corrected_bytes += corrected
              if self.verbose and (corrected or self.rx_count == 1 or
                                   self.rx_count % self.log_every == 0):
                  print(f'[RS RX #{self.rx_count}] {len(raw)} -> {len(decoded)} bytes; '
                        f'codewords={nwords}; corrected bytes={corrected}; '
                        'CRC/authentication/file verification follow', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS RX SUMMARY] received={self.rx_count}; decoded={self.decoded_count}; '
                        f'RS failures={self.fail_count}; corrected packets={self.corrected_packets}; '
                        f'corrected bytes={self.corrected_bytes}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: epy_rs_encoder
  id: epy_block
  parameters:
    _source_code: |
      """Multi-codeword RS FEC for encrypted transceiver PDUs, including CRC32.
      Each 239-byte segment gets 16 parity bytes at nsym=16. No extra wire header.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Encode all packet types (DATA, metadata, ACK and other controls)."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Encoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096  # Existing 4092-byte encrypted PDU budget + CRC32.
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.tx_count = self.reject_count = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: expected a packed-byte PDU', flush=True)
                  return
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              if not 4 <= len(raw) <= self.max_input:
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: packet must be 4..4096 bytes including CRC', flush=True)
                  return
              if self.enabled:
                  # Explicit boundaries prevent accidental changes to chunking conventions.
                  chunks = [bytes(self.rs.encode(raw[i:i+self.k]))
                            for i in range(0, len(raw), self.k)]
                  encoded = b''.join(chunks)
                  nwords = len(chunks)
              else:
                  encoded, nwords = raw, 0
              meta = pmt.car(msg)
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(encoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(encoded), list(encoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.tx_count += 1
              if self.verbose and (self.tx_count == 1 or self.tx_count % self.log_every == 0):
                  print(f'[RS TX #{self.tx_count}] {len(raw)} -> {len(encoded)} bytes; '
                        f'codewords={nwords}; FEC={self.enabled}', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS TX SUMMARY] packets={self.tx_count}; rejected={self.reject_count}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: epy_training_correlator
  id: epy_block
  parameters:
    _source_code: |
      # Pixel Pulse: all project radio modules are embedded below.
      # No sdrchat checkout or separately supplied Python blocks are required.
      import importlib.abc as _abc
      import importlib.util as _util
      import sys as _sys
      import types as _types

      _RADIO_SOURCES = {'config': 'import json\n'
                 'from pathlib import Path\n'
                 '\n'
                 '\n'
                 'def load(path):\n'
                 '    path = Path(path).resolve()\n'
                 '    c = json.loads(path.read_text())\n'
                 "    if not 1 <= c['address'] <= 65534:\n"
                 "        raise ValueError('Node address must be 0x0001..0xFFFE')\n"
                 "    c['state_dir'] = str((path.parent / c['state_dir']).resolve())\n"
                 "    c['config_path'] = str(path)\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n'
                 '\n'
                 '\n'
                 'def addr(value):\n'
                 "    return f'0x{int(value):04X}'\n"
                 '\n'
                 '\n'
                 "_DEFAULT_CONFIG = {'address': 16170, 'name': 'User 1', 'frequency': 2426500000, 'uri': "
                 "'ip:192.168.1.10', 'commands_port': 5555, 'events_port': 5556, 'shared_key': "
                 "'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=', 'state_dir': './data/node_a', 'sample_rate': "
                 "2400000, 'cs_threshold_db': -35.0, 'cs_hysteresis_db': 3.0, 'difs_s': 0.02, 'slot_s': 0.015, "
                 "'ack_timeout_s': 1.0, 'retry_limit': 20, 'cw_min': [8, 16, 32], 'cw_max': 1024, 'aging_s': 30.0, "
                 "'tx_delay_s': 0.02, 'tx_guard_s': 0.01, 'tx_attenuation_db': 0.0, 'rx_gain_db': 45, 'nlms_taps': "
                 "7, 'nlms_mu': 0.2, 'nlms_dd_mu': 0.02, 'nlms_eps': 1e-06, 'correlation_threshold': 0.6, "
                 "'contacts': [], 'local_radio_configured': True}\n"
                 '_original_load = load\n'
                 '\n'
                 'def load(path):\n'
                 '    import os\n'
                 '    path = Path(path)\n'
                 '    if path.exists():\n'
                 '        return _original_load(path)\n'
                 "    if os.environ.get('SDRCHAT_CONFIG') or str(path) != 'configs/node_a.json':\n"
                 "        raise FileNotFoundError('Node configuration does not exist: ' + str(path))\n"
                 '    c = dict(_DEFAULT_CONFIG)\n'
                 "    c['state_dir'] = str(Path(c['state_dir']).resolve())\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n',
       'engine': '"""Durable, single-flight ARQ with CSMA/CA. Owned by the radio process."""\n'
                 'import hashlib\n'
                 'import json\n'
                 'import random\n'
                 'import sqlite3\n'
                 'import time\n'
                 'import uuid\n'
                 'from collections import deque\n'
                 'from pathlib import Path\n'
                 'from cryptography.fernet import InvalidToken\n'
                 'from .protocol import Codec, TEXT, ACK, BROADCAST, make_fragment, parse_fragment\n'
                 '\n'
                 '\n'
                 'class Engine:\n'
                 '    def __init__(self, config, transmit, event, clock=time.monotonic, rng=None):\n'
                 "        self.c=config; self.me=config['address']; self.transmit=transmit; self.event=event\n"
                 '        self.clock=clock; self.rng=rng or random.SystemRandom(); '
                 "self.codec=Codec(config['shared_key'])\n"
                 "        self.db=sqlite3.connect(str(Path(config['state_dir'])/'radio.sqlite'))\n"
                 "        self.db.execute('PRAGMA journal_mode=WAL'); self.db.execute('PRAGMA synchronous=FULL')\n"
                 "        self.db.executescript('''\n"
                 '        CREATE TABLE IF NOT EXISTS jobs(id TEXT PRIMARY KEY,dst INTEGER,priority INTEGER,kind '
                 'TEXT,name TEXT,data BLOB,created REAL,status TEXT,part INTEGER DEFAULT 0);\n'
                 '        CREATE TABLE IF NOT EXISTS fragments(src INTEGER,id TEXT,part INTEGER,total INTEGER,meta '
                 'TEXT,data BLOB,PRIMARY KEY(src,id,part));\n'
                 '        CREATE TABLE IF NOT EXISTS receipts(src INTEGER,seq INTEGER,digest TEXT,PRIMARY '
                 'KEY(src,seq));\n'
                 '        CREATE TABLE IF NOT EXISTS received(src INTEGER,id TEXT,kind TEXT,name TEXT,data '
                 'BLOB,PRIMARY KEY(src,id));\n'
                 '        CREATE TABLE IF NOT EXISTS settings(key TEXT PRIMARY KEY,value INTEGER);\n'
                 "        ''')\n"
                 '        self.db.execute("INSERT OR IGNORE INTO settings '
                 'VALUES(\'sequence\',?)",(self.rng.randrange(1,2**30),))\n'
                 '        self.db.execute("UPDATE jobs SET status=\'queued\' WHERE status IN '
                 '(\'sending\',\'sent\')")\n'
                 '        self.db.commit()\n'
                 '        self.queues=[deque(),deque(),deque()]\n'
                 '        self.jobs={}; self.current=None; self.flight=None; self.acks=deque(); '
                 'self.ack_keys=set()\n'
                 '        self.contender=None; self.idle_since=None; self.tx_until=0; self.busy=True\n'
                 '        self.power=-200.; self.sense_at=-1e9; self.last_status=-1e9\n'
                 '        for row in self.db.execute("SELECT id,dst,priority,kind,name,data,created,part FROM jobs '
                 'WHERE status=\'queued\' ORDER BY created,rowid"):\n'
                 "            j=dict(zip(('id','dst','priority','kind','name','data','created','part'),row))\n"
                 "            j['enqueued']=self.clock()-max(0,time.time()-j['created']); self.jobs[j['id']]=j\n"
                 "            self.queues[j['priority']].append(j)\n"
                 '\n'
                 '    def close(self):\n'
                 '        self.db.close()\n'
                 '\n'
                 '    def status(self, ident, state, **extra):\n'
                 "        self.db.execute('UPDATE jobs SET status=? WHERE id=?',(state,ident)); self.db.commit()\n"
                 "        self.event(dict(event='status',id=ident,status='sent' if state=='broadcast_sent' else "
                 'state,**extra))\n'
                 '\n'
                 '    def enqueue(self, command):\n'
                 "        ident=str(uuid.UUID(command['id']))\n"
                 "        found=self.db.execute('SELECT status FROM jobs WHERE id=?',(ident,)).fetchone()\n"
                 '        if found:\n'
                 "            self.event(dict(event='status',id=ident,status='sent' if found[0]=='broadcast_sent' "
                 'else found[0])); return\n'
                 "        dst=int(command['dst']); pri=int(command['priority']); kind=command['kind']\n"
                 '        if dst==self.me or not 1<=dst<=BROADCAST or pri not in (0,1,2):\n'
                 "            raise ValueError('Invalid destination or priority')\n"
                 "        if kind=='text':\n"
                 "            data=command['text'].encode('utf-8'); name='message.txt'\n"
                 "            if not 0<len(data)<=65536: raise ValueError('Text must contain 1..65536 UTF-8 "
                 "bytes')\n"
                 "        elif kind in ('image','audio','file'):\n"
                 "            p=Path(command['path']).resolve()\n"
                 '            if not p.is_file() or not 0<p.stat().st_size<=16*1024*1024:\n'
                 "                raise ValueError('Choose a nonempty file up to 16 MiB')\n"
                 "            data=p.read_bytes(); name=str(command.get('name',p.name))[:120]\n"
                 "        else: raise ValueError('Unknown message type')\n"
                 '        j=dict(id=ident,dst=dst,priority=pri,kind=kind,name=name,data=data,\n'
                 '               created=time.time(),part=0,enqueued=self.clock())\n'
                 "        self.db.execute('INSERT INTO jobs VALUES(?,?,?,?,?,?,?,?,?)',\n"
                 "            (ident,dst,pri,kind,name,data,j['created'],'queued',0)); self.db.commit()\n"
                 '        self.jobs[ident]=j; self.queues[pri].append(j)\n'
                 "        self.status(ident,'queued')\n"
                 '\n'
                 '    def snapshot(self):\n'
                 "        for ident,status in self.db.execute('SELECT id,status FROM jobs'):\n"
                 "            self.event(dict(event='status',id=ident,status='sent' if status=='broadcast_sent' "
                 'else status))\n'
                 "        for src,ident,kind,name,data in self.db.execute('SELECT src,id,kind,name,data FROM "
                 "received'):\n"
                 '            self.deliver_event(src,ident,kind,name,data)\n'
                 '\n'
                 '    def deliver_event(self, src, ident, kind, name, data):\n'
                 "        info=dict(event='received',id=ident,src=src,kind=kind,name=name)\n"
                 "        if kind=='text': info['text']=data.decode('utf-8')\n"
                 '        else:\n'
                 "            directory=Path(self.c['state_dir'])/'received'; directory.mkdir(exist_ok=True)\n"
                 "            safe=''.join(c if c.isalnum() or c in '.-_ ' else '_' for c in "
                 'Path(name).name)[:120]\n'
                 "            path=directory/(str(src)+'_'+ident+'_'+safe)\n"
                 '            if not path.exists():\n'
                 '                '
                 "temp=path.with_suffix(path.suffix+'.part');temp.write_bytes(data);temp.replace(path)\n"
                 "            info['path']=str(path)\n"
                 '        self.event(info)\n'
                 '\n'
                 '    def sense(self, power_db, busy=None):\n'
                 '        self.power=float(power_db); self.sense_at=self.clock()\n'
                 '        if busy is None:\n'
                 "            limit=self.c['cs_threshold_db']-(self.c['cs_hysteresis_db'] if self.busy else 0)\n"
                 '            self.busy=self.power>limit\n'
                 '        else:self.busy=bool(busy)\n'
                 '        if self.busy:\n'
                 '            self.idle_since=None\n'
                 "            if self.contender:self.contender.pop('slot_at',None)\n"
                 '\n'
                 '    def receive(self, wire):\n'
                 '        try:\n'
                 '            f=self.codec.unpack(wire,self.me)\n'
                 "            if f['typ']==ACK:\n"
                 '                p=self.flight\n'
                 "                if p and p.get('sent_once') and f['dst']==self.me and f['src']==p['dst'] and "
                 "f['seq']==p['seq'] and f['body']==uuid.UUID(self.current['id']).bytes:\n"
                 '                    self.complete_packet()\n'
                 '                return\n'
                 '            digest=hashlib.sha256(wire).hexdigest()\n'
                 "            receipt=self.db.execute('SELECT digest FROM receipts WHERE src=? AND "
                 "seq=?',(f['src'],f['seq'])).fetchone()\n"
                 "            ident,index,count,meta,data=parse_fragment(f['body'])\n"
                 '            if receipt and receipt[0]!=digest: return\n'
                 '            if not receipt:\n'
                 '                # Completed messages may be retransmitted with a new sequence after a restart.\n'
                 "                done=self.db.execute('SELECT 1 FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 '                if not done:\n'
                 '                    m=json.dumps(meta,sort_keys=True)\n'
                 "                    existing=self.db.execute('SELECT meta,data FROM fragments WHERE src=? AND "
                 "id=? AND part=?',(f['src'],ident,index)).fetchone()\n"
                 "                    if existing and existing!=(m,data):raise ValueError('Conflicting fragment')\n"
                 "                    other=self.db.execute('SELECT meta FROM fragments WHERE src=? AND id=? LIMIT "
                 "1',(f['src'],ident)).fetchone()\n"
                 "                    if other and other[0]!=m:raise ValueError('Conflicting metadata')\n"
                 "                    self.db.execute('INSERT OR IGNORE INTO fragments "
                 "VALUES(?,?,?,?,?,?)',(f['src'],ident,index,count,m,data))\n"
                 "                    rows=self.db.execute('SELECT data FROM fragments WHERE src=? AND id=? ORDER "
                 "BY part',(f['src'],ident)).fetchall()\n"
                 '                    if len(rows)==count:\n'
                 "                        full=b''.join(r[0] for r in rows)\n"
                 "                        if len(full)!=meta['size'] or "
                 "hashlib.sha256(full).hexdigest()!=meta['sha256']:\n"
                 "                            raise ValueError('Whole-message SHA-256 failure')\n"
                 "                        if meta['kind']=='text':full.decode('utf-8')\n"
                 "                        self.db.execute('INSERT INTO received "
                 "VALUES(?,?,?,?,?)',(f['src'],ident,meta['kind'],meta['name'],full))\n"
                 "                        self.db.execute('DELETE FROM fragments WHERE src=? AND "
                 "id=?',(f['src'],ident))\n"
                 "                self.db.execute('INSERT INTO receipts "
                 "VALUES(?,?,?)',(f['src'],f['seq'],digest)); self.db.commit()\n"
                 '                # Reconstruct delivery event from durable storage, before acknowledging '
                 'completion.\n'
                 "                received=self.db.execute('SELECT kind,name,data FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 "                if received:self.deliver_event(f['src'],ident,*received)\n"
                 "            if f['dst']!=BROADCAST and (f['src'],f['seq']) not in self.ack_keys:\n"
                 "                self.ack_keys.add((f['src'],f['seq']))\n"
                 "                raw=self.codec.pack(f['src'],self.me,f['seq'],0,ACK,uuid.UUID(ident).bytes)\n"
                 '                '
                 "self.acks.append(dict(wire=raw,ack=True,dst=f['src'],seq=f['seq'],cw=4,slots=None))\n"
                 '        except (ValueError,KeyError,TypeError,InvalidToken,UnicodeError) as exc:\n'
                 '            self.db.rollback()\n'
                 "            self.event(dict(event='diagnostic',message='RX rejected: '+str(exc)))\n"
                 '\n'
                 '    def choose(self):\n'
                 '        now=self.clock()\n'
                 "        heads=[(max(0,p-int((now-q[0]['enqueued'])/self.c['aging_s'])),q[0]['created'],p) for "
                 'p,q in enumerate(self.queues) if q]\n'
                 '        if not heads:return None\n'
                 '        _,_,p=min(heads)\n'
                 '        return self.queues[p].popleft()\n'
                 '\n'
                 '    def new_packet(self):\n'
                 '        j=self.current\n'
                 '        seq=self.db.execute("SELECT value FROM settings WHERE key=\'sequence\'").fetchone()[0]\n'
                 "        if seq>=0xFFFFFFFF:raise RuntimeError('Sequence space exhausted; provision a new node "
                 "address')\n"
                 '        self.db.execute("UPDATE settings SET value=? WHERE '
                 'key=\'sequence\'",(seq+1,));self.db.commit()\n'
                 "        body,count=make_fragment(j,j['part'])\n"
                 "        self.flight=dict(wire=self.codec.pack(j['dst'],self.me,seq,j['priority'],TEXT,body),\n"
                 '                         '
                 "dst=j['dst'],seq=seq,retries=0,cw=self.c['cw_min'][j['priority']],slots=None,\n"
                 '                         deadline=None,ack=False,count=count)\n'
                 '\n'
                 '    def complete_packet(self):\n'
                 '        j=self.current;p=self.flight\n'
                 '        if self.contender is p:self.contender=None\n'
                 "        j['part']+=1\n"
                 "        self.db.execute('UPDATE jobs SET part=? WHERE "
                 "id=?',(j['part'],j['id']));self.db.commit()\n"
                 '        self.flight=None\n'
                 "        if j['part']>=p['count']:\n"
                 "            self.status(j['id'],'broadcast_sent' if j['dst']==BROADCAST else "
                 "'delivered',broadcast=j['dst']==BROADCAST)\n"
                 "            self.jobs.pop(j['id'],None);self.current=None\n"
                 '        else:\n'
                 "            self.status(j['id'],'sending',progress=j['part']/p['count'])\n"
                 "            self.queues[j['priority']].appendleft(j);self.current=None\n"
                 '\n'
                 '    def tick(self):\n'
                 '        now=self.clock()\n'
                 '        if now-self.last_status>=0.5:\n'
                 "            self.event(dict(event='telemetry',power_db=self.power,busy=self.busy,\n"
                 '                            waiting=sum(map(len,self.queues)),active=bool(self.current),\n'
                 '                            queues=[len(q) for q in self.queues],address=self.me))\n'
                 '            self.last_status=now\n'
                 '        if now<self.tx_until:\n'
                 '            self.idle_since=None;return\n'
                 "        if self.flight and self.flight.get('broadcast_done'):\n"
                 '            self.complete_packet()\n'
                 "        if self.flight and self.flight['deadline'] is not None and "
                 "now>=self.flight['deadline']:\n"
                 '            p=self.flight\n'
                 "            if p['retries']>=self.c['retry_limit']:\n"
                 "                self.status(self.current['id'],'failed',reason='ACK timeout: retry limit "
                 "reached')\n"
                 "                self.jobs.pop(self.current['id'],None);self.current=None;self.flight=None\n"
                 '                if self.contender is p:self.contender=None\n'
                 '            else:\n'
                 "                p['retries']+=1;p['cw']=min(self.c['cw_max'],p['cw']*2)\n"
                 "                p['deadline']=None;p['slots']=None\n"
                 "                self.status(self.current['id'],'sending',retry=p['retries'])\n"
                 '        if self.current is None:\n'
                 '            self.current=self.choose()\n'
                 '        if self.current and self.flight is None:self.new_packet()\n'
                 '        # ACKs have a separate control queue. They never wait behind a data ACK timeout.\n'
                 '        if self.acks:\n'
                 '            candidate=self.acks[0]\n'
                 "        elif self.flight and self.flight['deadline'] is None:\n"
                 '            candidate=self.flight\n'
                 '        else:\n'
                 '            self.contender=None;return\n'
                 '        if candidate is not self.contender:\n'
                 "            self.contender=candidate; self.idle_since=None;candidate.pop('slot_at',None)\n"
                 '        if self.busy or now-self.sense_at>0.2:\n'
                 "            self.idle_since=None;candidate.pop('slot_at',None);return\n"
                 '        if self.idle_since is None:self.idle_since=now\n'
                 "        if now-self.idle_since<self.c['difs_s']:return\n"
                 "        if candidate['slots'] is None:\n"
                 "            candidate['slots']=self.rng.randrange(candidate['cw']);candidate['slot_at']=now\n"
                 "        elif 'slot_at' not in candidate:candidate['slot_at']=now\n"
                 "        slots=int((now-candidate['slot_at'])/self.c['slot_s'])\n"
                 "        candidate['slots']=max(0,candidate['slots']-slots)\n"
                 "        candidate['slot_at']+=slots*self.c['slot_s']\n"
                 "        if candidate['slots']:return\n"
                 "        if not candidate['ack']:self.status(self.current['id'],'sending')\n"
                 "        try:duration=float(self.transmit(candidate['wire']))\n"
                 '        except Exception as exc:\n'
                 "            self.event(dict(event='diagnostic',message='TX unavailable: '+str(exc)))\n"
                 "            candidate['slots']=None;self.idle_since=None;return\n"
                 '        self.tx_until=now+duration;self.idle_since=None;self.contender=None\n'
                 "        if candidate['ack']:\n"
                 "            self.acks.popleft();self.ack_keys.discard((candidate['dst'],candidate['seq']))\n"
                 '        else:\n'
                 "            candidate['sent_once']=True\n"
                 "            candidate['deadline']=self.tx_until+self.c['ack_timeout_s']\n"
                 "            if candidate['dst']==BROADCAST:candidate['broadcast_done']=True\n"
                 "            self.status(self.current['id'],'sent',retry=candidate['retries'])\n",
       'equalizer': 'import ctypes\n'
                    'import hashlib\n'
                    'from pathlib import Path\n'
                    'import numpy as np\n'
                    'import pmt\n'
                    'from gnuradio import gr\n'
                    '\n'
                    '\n'
                    'def training_bytes(length=2048):\n'
                    "    return b''.join(hashlib.sha256(b'QPSK-training-v1'+i.to_bytes(4,'big')).digest()\n"
                    '                    for i in range((length+31)//32))[:length]\n'
                    '\n'
                    '\n'
                    'def training_symbols():\n'
                    '    # Last 64 bytes of the EXISTING deterministic prefix. Constant differential\n'
                    '    # phase before this segment is absorbed by training; no change to TX bytes.\n'
                    '    bits=np.unpackbits(np.frombuffer(training_bytes()[-64:],dtype=np.uint8)).reshape(-1,2)\n'
                    '    chunks=bits[:,0]*2+bits[:,1]\n'
                    '    mapped=np.array([0,1,3,2])[chunks]\n'
                    '    index=np.cumsum(mapped)%4\n'
                    '    return np.array([.707+.707j,-.707+.707j,-.707-.707j,.707-.707j],np.complex64)[index]\n'
                    '\n'
                    '\n'
                    'class TrainingCorrelator(gr.sync_block):\n'
                    '    def __init__(self, threshold=.6):\n'
                    "        gr.sync_block.__init__(self,name='QPSK training "
                    "correlator',in_sig=[np.complex64],out_sig=[np.complex64])\n"
                    '        symbols=training_symbols()[:64]\n'
                    '        t=np.arange(-8,9)/2.;a=.35\n'
                    '        pulse=np.sinc(t)*np.cos(np.pi*a*t)/(1-(2*a*t)**2)\n'
                    '        '
                    'self.ref=np.convolve(np.kron(symbols,[1,0]),pulse)[8:8+2*len(symbols)-1].astype(np.complex64)\n'
                    '        self.energy=float(np.vdot(self.ref,self.ref).real);self.threshold=threshold\n'
                    '        self.delay=(len(self.ref)+9)//2*2\n'
                    '        self.set_history(self.delay+1);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '        self.next_position=0;self.last_position=-10000;self.count=0\n'
                    '\n'
                    '    def work(self, inputs, outputs):\n'
                    '        x=inputs[0];out=outputs[0];n=len(out);out[:]=x[:n]\n'
                    '        base=self.nitems_written(0)-self.delay\n'
                    "        c=np.correlate(x,self.ref,'valid')\n"
                    "        power=np.convolve(np.abs(x).astype(np.float64)**2,np.ones(len(self.ref)),'valid')\n"
                    '        score=np.abs(c)**2/(self.energy*power+1e-12)\n'
                    '        '
                    'lo=max(self.next_position-base,2,-base);hi=min(len(score)-3,n+self.delay-len(self.ref))\n'
                    '        for j in np.flatnonzero(score[lo:hi+1]>self.threshold)+lo:\n'
                    '            if score[j]<max(score[j-2:j]) or score[j]<=max(score[j+1:j+3]):continue\n'
                    '            absolute=base+int(j)\n'
                    '            if absolute-self.last_position<512:continue\n'
                    '            offset=absolute+self.delay\n'
                    '            if offset<self.nitems_written(0):continue\n'
                    '            '
                    "self.add_item_tag(0,offset,pmt.intern('corr_est'),pmt.from_double(float(score[j])))\n"
                    '            self.last_position=absolute;self.count+=1\n'
                    '        if hi>=lo:self.next_position=base+hi+1\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    'class NLMS(gr.decim_block):\n'
                    '    def __init__(self,taps=7,mu=.2,dd_mu=.02,eps=1e-6):\n'
                    "        gr.decim_block.__init__(self,name='Regularized QPSK "
                    "NLMS',in_sig=[np.complex64],out_sig=[np.complex64],decim=2)\n"
                    '        if taps<3 or taps%2!=1 or not 0<mu<2 or not 0<dd_mu<2 or eps<=0:raise '
                    "ValueError('Invalid NLMS parameters')\n"
                    '        self.taps=taps;self.mu=mu;self.dd_mu=dd_mu;self.eps=eps\n'
                    '        self.weights=np.zeros(taps,np.complex64);self.weights[0]=1\n'
                    '        '
                    'self.training=training_symbols();self.pos=ctypes.c_int(0);self.active=ctypes.c_int(0)\n'
                    '        lib=_embedded_native_library()\n'
                    "        if not lib.exists():raise RuntimeError('Run ./setup.sh to build the NLMS kernel')\n"
                    '        self.lib=ctypes.CDLL(str(lib));self.fn=self.lib.nlms_process\n'
                    '        '
                    'self.fn.argtypes=[ctypes.c_void_p,ctypes.c_void_p,ctypes.c_int,ctypes.c_int,ctypes.c_void_p,\n'
                    '            '
                    'ctypes.c_void_p,ctypes.c_int,ctypes.POINTER(ctypes.c_int),ctypes.POINTER(ctypes.c_int),\n'
                    '            '
                    'ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_void_p,ctypes.c_int]\n'
                    '        '
                    'self.fn.restype=None;self.set_history(taps);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '\n'
                    '    def work(self,inputs,outputs):\n'
                    '        x=inputs[0];y=outputs[0];n=len(y)\n'
                    "        tags=self.get_tags_in_window(0,0,2*n,pmt.intern('corr_est'))\n"
                    '        starts=np.array([int(t.offset-self.nitems_read(0)) for t in tags],np.int32)\n'
                    '        self.fn(x.ctypes.data,y.ctypes.data,n,self.taps,self.weights.ctypes.data,\n'
                    '                '
                    'self.training.ctypes.data,len(self.training),ctypes.byref(self.pos),ctypes.byref(self.active),\n'
                    '                self.mu,self.dd_mu,self.eps,1e-8,starts.ctypes.data,len(starts))\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    "_NATIVE_SOURCE = '// Batched regularized complex NLMS. y = w^H x, e = d-y.\\n#include "
                    '<complex>\\n#include <cmath>\\n#include <algorithm>\\nusing C = std::complex<float>;\\nextern '
                    '"C" void nlms_process(const C* input, C* output, int n, int '
                    'taps,\\n                              C* weights, const C* training, int '
                    'training_len,\\n                              int* training_pos, int* active, float '
                    'mu,\\n                              float dd_mu, float eps, float '
                    'gate,\\n                              const int* starts, int nstarts) {\\n    int '
                    'tag=0;\\n    for(int i=0;i<n;i++) {\\n        if(tag<nstarts && starts[tag]<=2*i+1) '
                    '{\\n            *training_pos=0;*active=1;tag++;\\n            '
                    'std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);\\n        }\\n        const C* '
                    'newest=input+taps-1+2*i;\\n        C y(0,0);float power=0;\\n        for(int k=0;k<taps;k++) '
                    '{y+=std::conj(weights[k])*newest[-k];power+=std::norm(newest[-k]);}\\n        '
                    'output[i]=y;\\n        if(!*active || power<gate || !std::isfinite(power))continue;\\n        '
                    'bool train=*training_pos<training_len;\\n        C '
                    'desired=train?training[(*training_pos)++]:C(y.real()>=0?.707f:-.707f,y.imag()>=0?.707f:-.707f);\\n        '
                    'C error=desired-y;\\n        float step=(train?mu:dd_mu)/(eps+power);\\n        for(int '
                    'k=0;k<taps;k++)weights[k]+=step*std::conj(error)*newest[-k];\\n        // Disable adaptation '
                    'on catastrophic divergence; reacquire on next preamble.\\n        '
                    'if(!std::isfinite(std::norm(y)) || std::norm(y)>1e6f) '
                    "{*active=0;std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);}\\n    }\\n}\\n'\n"
                    '_native_directory = None\n'
                    '\n'
                    'def _embedded_native_library():\n'
                    '    global _native_directory\n'
                    '    import shutil\n'
                    '    import subprocess\n'
                    '    import tempfile\n'
                    '    if _native_directory is None:\n'
                    "        compiler = shutil.which('g++')\n"
                    '        if compiler is None:\n'
                    "            raise RuntimeError('The embedded NLMS source needs g++. Install g++ and run "
                    "again.')\n"
                    "        directory = tempfile.TemporaryDirectory(prefix='pixel-pulse-nlms-')\n"
                    '        folder = Path(directory.name)\n'
                    "        source = folder / 'nlms.cpp'\n"
                    '        source.write_text(_NATIVE_SOURCE)\n'
                    '        try:\n'
                    "            subprocess.run([compiler, '-O3', '-std=c++17', '-shared', '-fPIC', str(source), "
                    "'-o', str(folder / 'libnlms.so')], check=True, capture_output=True, text=True)\n"
                    '        except subprocess.CalledProcessError as exc:\n'
                    '            directory.cleanup()\n'
                    "            raise RuntimeError('Could not compile embedded NLMS source: ' + exc.stderr) from "
                    'exc\n'
                    '        _native_directory = directory\n'
                    "    return Path(_native_directory.name) / 'libnlms.so'\n",
       'protocol': '"""Network-order routing header + authenticated encrypted fragment or ACK.\n'
                   '\n'
                   'The GNU Radio graph adds CRC32 and RS outside this layer. The simulator uses\n'
                   'the same CRC and RS codec. Routing fields are repeated inside Fernet so they\n'
                   'cannot be altered without authentication failure.\n'
                   '"""\n'
                   'import hashlib\n'
                   'import json\n'
                   'import struct\n'
                   'import uuid\n'
                   'import zlib\n'
                   'from cryptography.fernet import Fernet\n'
                   'from .reedsolo_bundled import RSCodec\n'
                   '\n'
                   'TEXT, ACK = 1, 2\n'
                   'BROADCAST = 0xFFFF\n'
                   "HEADER = struct.Struct('!HHIBBH')\n"
                   "ROUTE = struct.Struct('!HHIBB')\n"
                   "FRAGMENT = struct.Struct('!16sHHH')\n"
                   '\n'
                   '\n'
                   'class Codec:\n'
                   '    def __init__(self, key):\n'
                   '        self.cipher = Fernet(key.encode() if isinstance(key, str) else key)\n'
                   '        self.rs = RSCodec(16, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8)\n'
                   '\n'
                   '    def pack(self, dst, src, seq, priority, typ, body):\n'
                   '        if not 1 <= src < BROADCAST or not 1 <= dst <= BROADCAST:\n'
                   "            raise ValueError('Invalid address')\n"
                   '        if priority not in (0, 1, 2) or typ not in (TEXT, ACK):\n'
                   "            raise ValueError('Invalid priority or packet type')\n"
                   '        route = ROUTE.pack(dst, src, seq, priority, typ)\n'
                   '        token = self.cipher.encrypt(route + body)\n'
                   '        wire = HEADER.pack(dst, src, seq, priority, typ, len(token)) + token\n'
                   '        if len(wire) > 4092:\n'
                   "            raise ValueError('Frame exceeds original 4092-byte budget')\n"
                   '        return wire\n'
                   '\n'
                   '    def unpack(self, wire, me):\n'
                   '        if len(wire) < HEADER.size or len(wire) > 4092:\n'
                   "            raise ValueError('Invalid frame size')\n"
                   '        dst, src, seq, pri, typ, length = HEADER.unpack_from(wire)\n'
                   '        if dst not in (me, BROADCAST) or src == me or not 1 <= src < BROADCAST:\n'
                   "            raise ValueError('Frame for another node or own echo')\n"
                   '        if length != len(wire)-HEADER.size or pri not in (0,1,2) or typ not in (TEXT,ACK):\n'
                   "            raise ValueError('Malformed header')\n"
                   '        raw = self.cipher.decrypt(wire[HEADER.size:])\n'
                   '        if raw[:ROUTE.size] != ROUTE.pack(dst,src,seq,pri,typ):\n'
                   "            raise ValueError('Authenticated routing mismatch')\n"
                   '        return dict(dst=dst, src=src, seq=seq, priority=pri, typ=typ, body=raw[ROUTE.size:])\n'
                   '\n'
                   '    def protect(self, raw):\n'
                   "        data = raw + struct.pack('!I', zlib.crc32(raw))\n"
                   '        return bytes(self.rs.encode(data))\n'
                   '\n'
                   '    def recover(self, coded):\n'
                   '        data = bytes(self.rs.decode(coded)[0])\n'
                   "        if len(data)<4 or zlib.crc32(data[:-4]) != struct.unpack('!I',data[-4:])[0]:\n"
                   "            raise ValueError('CRC failure')\n"
                   '        return data[:-4]\n'
                   '\n'
                   '\n'
                   'def make_fragment(job, index):\n'
                   "    data = job['data']\n"
                   "    chunk = 128 if job['kind']=='text' else 1024\n"
                   '    count = max(1, (len(data)+chunk-1)//chunk)\n'
                   "    meta = json.dumps(dict(kind=job['kind'], name=job['name'], size=len(data),\n"
                   '                           '
                   "sha256=hashlib.sha256(data).hexdigest()),separators=(',',':')).encode()\n"
                   '    return '
                   "FRAGMENT.pack(uuid.UUID(job['id']).bytes,index,count,len(meta))+meta+data[index*chunk:(index+1)*chunk], "
                   'count\n'
                   '\n'
                   '\n'
                   'def parse_fragment(body):\n'
                   '    if len(body)<FRAGMENT.size:\n'
                   "        raise ValueError('Truncated fragment')\n"
                   '    ident,index,count,mlen = FRAGMENT.unpack_from(body)\n'
                   '    if not 1<=count<=16384 or index>=count or not 0<mlen<=1024:\n'
                   "        raise ValueError('Invalid fragmentation')\n"
                   '    meta = json.loads(body[FRAGMENT.size:FRAGMENT.size+mlen])\n'
                   "    if meta['kind'] not in ('text','image','audio','file') or not "
                   "0<meta['size']<=16*1024*1024:\n"
                   "        raise ValueError('Invalid transfer metadata')\n"
                   "    chunk = 128 if meta['kind']=='text' else 1024\n"
                   "    if meta['kind']=='text' and meta['size']>65536:\n"
                   "        raise ValueError('Text exceeds original 64 KiB limit')\n"
                   "    if count != (meta['size']+chunk-1)//chunk:\n"
                   "        raise ValueError('Wrong fragment count')\n"
                   '    data=body[FRAGMENT.size+mlen:]\n'
                   "    if len(data)!=min(chunk,meta['size']-index*chunk):\n"
                   "        raise ValueError('Wrong fragment length')\n"
                   '    return str(uuid.UUID(bytes=ident)),index,count,meta,data\n',
       'radio_blocks': 'import os\n'
                       'import queue\n'
                       'import threading\n'
                       'import time\n'
                       'import numpy as np\n'
                       'import pmt\n'
                       'from gnuradio import gr\n'
                       'from .config import load\n'
                       'from .service import Service\n'
                       '\n'
                       '\n'
                       'def airtime(c, raw_length):\n'
                       '    """Estimate a framed RF burst including host delay and turnaround guard."""\n'
                       '    coded=raw_length+4+16*((raw_length+4+238)//239)\n'
                       "    return (2048+12+coded+2570)*16/c['sample_rate']+c['tx_delay_s']+c['tx_guard_s']\n"
                       '\n'
                       '\n'
                       'class MacBridge(gr.sync_block):\n'
                       '    """Raw RX energy observer + PDU socket/MAC service. No stream output."""\n'
                       "    def __init__(self,config_path='configs/node_a.json'):\n"
                       "        gr.sync_block.__init__(self,name='CSMA/CA + app "
                       "bridge',in_sig=[np.complex64],out_sig=None)\n"
                       '        self.c=load(config_path);self.incoming=queue.Queue(maxsize=4096)\n'
                       '        '
                       'self.reading=None;self.read_at=0;self.lock=threading.Lock();self.tx_lock=threading.Lock()\n'
                       '        self.tx_at=0;self.tx_end=0;self.sink=None;self.source=None;self.muted=True\n'
                       '        '
                       "self.message_port_register_in(pmt.intern('rx_in'));self.set_msg_handler(pmt.intern('rx_in'),self.receive)\n"
                       "        self.message_port_register_out(pmt.intern('tx_out'))\n"
                       '        self.service=Service(self.c,self.send,self.incoming,self.sensor)\n'
                       '\n'
                       '    def attach_radio(self,sink,source):\n'
                       '        self.sink=sink;self.source=source\n'
                       '\n'
                       '    def start(self):\n'
                       "        if self.sink is None:raise RuntimeError('Launch with python3 -m sdrchat.hardware; "
                       "radio mute hook is required')\n"
                       '        self.sink.set_attenuation(0,89.75)\n'
                       '        self.service.start();return True\n'
                       '\n'
                       '    def stop(self):\n'
                       '        self.service.stop()\n'
                       '        if self.sink:self.sink.set_attenuation(0,89.75)\n'
                       '        return True\n'
                       '\n'
                       '    def sensor(self):\n'
                       '        now=time.monotonic()\n'
                       '        if not self.muted and now>=self.tx_end:\n'
                       '            self.sink.set_attenuation(0,89.75);self.muted=True\n'
                       '        with self.lock:\n'
                       '            if now-self.read_at>.1:return None\n'
                       '            return self.reading,None\n'
                       '\n'
                       '    def send(self,wire):\n'
                       "        if self.sink is None:raise RuntimeError('Radio sink not attached')\n"
                       "        self.sink.set_attenuation(0,self.c['tx_attenuation_db']);self.muted=False\n"
                       '        duration=airtime(self.c,len(wire))\n'
                       '        self.tx_at=time.monotonic();self.tx_end=self.tx_at+duration\n'
                       '        '
                       "self.message_port_pub(pmt.intern('tx_out'),pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(wire),list(wire))))\n"
                       '        return duration\n'
                       '\n'
                       '    def receive(self,msg):\n'
                       '        # Ignore own RF echo during the estimated transmission/turnaround window.\n'
                       '        if time.monotonic()<self.tx_end:return\n'
                       '        if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):\n'
                       '            try:self.incoming.put_nowait(bytes(pmt.u8vector_elements(pmt.cdr(msg))))\n'
                       '            except queue.Full:pass\n'
                       '\n'
                       '    def work(self,inputs,outputs):\n'
                       '        x=inputs[0]\n'
                       '        if len(x):\n'
                       '            power=10*np.log10(max(float(np.mean(np.abs(x)**2)),1e-20))\n'
                       '            with self.lock:self.reading=power;self.read_at=time.monotonic()\n'
                       '        return len(x)\n',
       'reedsolo_bundled': '#!/usr/bin/env python\n'
                           '# -*- coding: utf-8 -*-\n'
                           '\n'
                           '# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n'
                           '# Copyright (c) 2015 rotorgit\n'
                           '# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n'
                           '\n'
                           "'''\n"
                           'Reed Solomon\n'
                           '============\n'
                           '\n'
                           'A pure-python `universal errors-and-erasures Reed-Solomon Codec '
                           '<http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n'
                           ', based on the wonderful tutorial at\n'
                           '`wikiversity '
                           '<http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\n'
                           'written by "Bobmath" and "LRQ3000".\n'
                           '\n'
                           'The code of wikiversity is here consolidated into a nice API with exceptions '
                           'handling.\n'
                           'The algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\n'
                           'v the number of erasures and nsym = n-k = the number of ECC (error correction code) '
                           'symbols.\n'
                           'This means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n'
                           '(errors where you know the position), and a combination of both errors and erasures.\n'
                           'The code should work on pretty much any reasonable version of python (2.4-3.5),\n'
                           "but I'm only testing on 2.7 - 3.4.\n"
                           '\n'
                           '.. note::\n'
                           '   The codec is universal, meaning that it can decode any message encoded by another '
                           'RS encoder\n'
                           '   as long as you provide the correct parameters.\n'
                           '   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will '
                           'be slower, first because\n'
                           "   we cannot then use the optimized bytearray() structure but only array.array('i', "
                           '...), and also because\n'
                           "   Reed-Solomon's complexity is quadratic (both in encoding and decoding), so this "
                           'means that the longer\n'
                           '   your messages, the longer it will take to encode/decode (quadratically!).\n'
                           '\n'
                           '   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the '
                           'ECC symbols,\n'
                           '   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message '
                           'length and the maximum\n'
                           '   value for one character is constrained by the same mathematical reason). By '
                           'default, we use the field GF(2^8),\n'
                           '   which means that you are limited to values between 0 and 255 (perfect to represent '
                           'a single hexadecimal\n'
                           '   symbol on computers, so you can encode any binary stream) and limited to '
                           'messages+ecc of maximum\n'
                           '   length 255. However, you can "chunk" longer messages to fit them into the message '
                           'length limit.\n'
                           '   The ``RSCodec`` class will automatically apply chunking, by splitting longer '
                           'messages into chunks and\n'
                           "   encode/decode them separately; it shouldn't make a difference from an API "
                           'perspective (ie, from your POV).\n'
                           '\n'
                           '::\n'
                           '\n'
                           '    # Initialization\n'
                           '    >>> from reedsolo import RSCodec\n'
                           '    >>> rsc = RSCodec(10)  # 10 ecc symbols\n'
                           '\n'
                           '    # Encoding\n'
                           '    >>> rsc.encode([1,2,3,4])\n'
                           "    b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M'\n"
                           '    >>> rsc.encode(bytearray([1,2,3,4]))\n'
                           "    bytearray(b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M')\n"
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa'\n"
                           '    # Note that chunking is supported transparently to encode any string length.\n'
                           '\n'
                           '    # Decoding (repairing)\n'
                           "    >>> rsc.decode(b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa')[0]\n"
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 3 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 5 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa')[0]        # 6 "
                           'errors - fail\n'
                           '    Traceback (most recent call last):\n'
                           '      ...\n'
                           '    ReedSolomonError: Could not locate error\n'
                           '\n'
                           '    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 '
                           'erasures)\n'
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2='\n"
                           "    >>> rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')[0]         # 6 "
                           'errors - ok\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=', erase_pos=[3, 4, 5, "
                           '6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n'
                           "    b'hello world'\n"
                           '\n'
                           '    # Checking\n'
                           "    >> rsc.check(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    [False]\n'
                           "    >> rmes, rmesecc = rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    # To use longer chunks or bigger values than 255 (may be very slow)\n'
                           '    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n'
                           '    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n'
                           "    >> mes = 'a' * (4095-12)\n"
                           '    >> mesecc = rsc.encode(mes)\n'
                           '    >> mesecc[2] = 1\n'
                           '    >> mesecc[-1] = 1\n'
                           '    >> rmes, rmesecc = rsc.decode(mesecc)\n'
                           '    >> rsc.check(mesecc)\n'
                           '    [False]\n'
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    If you want full control, you can skip the API and directly use the library as-is. '
                           "Here's how:\n"
                           '\n'
                           '    First you need to init the precomputed tables:\n'
                           '    >> import reedsolo as rs\n'
                           '    >> rs.init_tables(0x11d)\n'
                           '    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please '
                           'check that your prime polynomial is correct for your field.\n'
                           '    Pro tip2: by default, you can only encode messages of max length and max symbol '
                           'value = 256. If you want to encode bigger messages,\n'
                           '    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 '
                           '= max length 2^12 = 4096):\n'
                           '    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n'
                           '    >> rs.init_tables(c_exp=12, prim=prim)\n'
                           '    \n'
                           "    Let's define our RS message and ecc size:\n"
                           '    >> n = 255  # length of total message+ecc\n'
                           '    >> nsym = 12  # length of ecc\n'
                           '    >> mes = "a" * (n-nsym)  # generate a sample message\n'
                           '\n'
                           '    To optimize, you can precompute the generator polynomial:\n'
                           '    >> gen = rs.rs_generator_poly_all(n)\n'
                           '\n'
                           '    Then to encode:\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n'
                           '\n'
                           "    Let's tamper our message:\n"
                           '    >> mesecc[1] = 0\n'
                           '\n'
                           '    To decode:\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n'
                           '    Note that both the message and the ecc are corrected (if possible of course).\n'
                           '    Pro tip: if you know a few erasures positions, you can specify them in a list '
                           '`erase_pos` to double the repair power. But you can also just specify an empty list.\n'
                           '\n'
                           '    If the decoding fails, it will normally automatically check and raise a '
                           'ReedSolomonError exception that you can handle.\n'
                           '    However if you want to manually check if the repaired message is correct, you can '
                           'do so:\n'
                           '    >> rs.rs_check(rmes + recc, nsym)\n'
                           '\n'
                           '    Note: if you want to use multiple reedsolomon with different parameters, you need '
                           'to backup the globals and restore them before calling reedsolo functions:\n'
                           '    >> rs.init_tables()\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n'
                           '    Then at anytime, you can do:\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym)\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n'
                           '    The globals backup is not necessary if you use RSCodec, it will be automatically '
                           'managed.\n'
                           '\n'
                           "    Read the sourcecode's comments for more info about how it works, and for the "
                           'various parameters you can setup if\n'
                           '    you need to interface with other RS codecs.\n'
                           '\n'
                           "'''\n"
                           '\n'
                           '# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials '
                           'inside lists throughout the code and functions (because for now there are a lot of '
                           'list reversing in order to make it work, you never know the order of a polynomial, ie, '
                           'if the first coefficient is the major degree or the constant term...).\n'
                           '\n'
                           'import itertools\n'
                           'import math\n'
                           '\n'
                           '\n'
                           '################### INIT and stuff ###################\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    bytearray\n'
                           '    _bytearray = bytearray\n'
                           'except NameError:  # pragma: no cover\n'
                           '    from array import array\n'
                           '    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n'
                           "        '''Simple bytearray replacement'''\n"
                           '        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '        if isinstance(obj, str):\n'
                           '            obj = [ord(ch) for ch in obj.encode(encoding)]\n'
                           '        elif isinstance(obj, int):\n'
                           '            obj = [0] * obj\n'
                           '        return array("B", obj)\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    # compatibility with Python 2.7\n'
                           '    xrange\n'
                           'except NameError:  # pragma: no cover\n'
                           '    # compatibility with Python 3+\n'
                           '    xrange = range\n'
                           '\n'
                           'class ReedSolomonError(Exception):\n'
                           '    pass\n'
                           '\n'
                           'gf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that '
                           'a simple multiplication of two numbers can be resolved without calling % 255. For more '
                           'infos on how to generate this extended exponentiation table, see paper: "Fast software '
                           'implementation of finite field operations", Cheng Huang and Lihao Xu, Washington '
                           'University in St. Louis, Tech. Rep (2003).\n'
                           'gf_log = _bytearray(256)\n'
                           'field_charac = int(2**8 - 1)\n'
                           '\n'
                           '################### GALOIS FIELD ELEMENTS MATHS ###################\n'
                           '\n'
                           'def rwh_primes1(n):\n'
                           '    # '
                           'http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n'
                           "    ''' Returns  a list of primes < n '''\n"
                           '    sieve = [True] * int(n/2)\n'
                           '    for i in xrange(3,int(n**0.5)+1,2):\n'
                           '        if sieve[int(i/2)]:\n'
                           '            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n'
                           '    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n'
                           '\n'
                           'def find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n'
                           "    '''Compute the list of prime polynomials for the given generator and galois field "
                           "characteristic exponent.'''\n"
                           '    # fast_primes will output less results but will be significantly faster.\n'
                           '    # single will output the first prime polynomial found, so if all you want is to '
                           'just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just '
                           'use that.\n'
                           '\n'
                           '    # A prime polynomial (necessarily irreducible) is necessary to reduce the '
                           'multiplications in the Galois Field, so as to avoid overflows.\n'
                           '    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for '
                           'GF(2^8) for example)? Because we need the values to be unique.\n'
                           '    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), '
                           'then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field '
                           'it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be '
                           'doubled (ie, next power of 2), which will give 256. Then we must reduce, because we '
                           'have overflowed above the maximum value of 255. But, if we modulo 255, this will '
                           'generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. '
                           "This is very bad, as it's then not anymore a bijection (ie, a non-zero value doesn't "
                           "have a unique index). That's why we can't just modulo 255, but we need another number "
                           'above 255, which is called the prime polynomial.\n'
                           '    # Why so much hassle? Because we are using precomputed look-up tables for '
                           'multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and '
                           'alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our '
                           'result. But just like in our original field we had 0,1,2,...,p-1 distinct unique '
                           'values, in our "LUT" field using alpha we must have unique distinct values (we don\'t '
                           'care that they are different from the original field as long as they are unique and '
                           "distinct). That's why we need to avoid duplicated values, and to avoid duplicated "
                           'values we need to use a prime irreducible polynomial.\n'
                           '\n'
                           '    # Here is implemented a bruteforce approach to find all these prime polynomials, '
                           'by generating every possible prime polynomials (ie, every integers between '
                           'field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we '
                           'reject the candidate prime polynomial if it duplicates even one value or if it '
                           'generates a value above field_charac (ie, cause an overflow).\n'
                           '    # Note that this algorithm is slow if the field is too big (above 12), because '
                           "it's an exhaustive search algorithm. There are probabilistic approaches, and almost "
                           'surely prime approaches, but there is no determistic polynomial time algorithm to find '
                           'irreducible monic polynomials. More info can be found at: '
                           'http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n'
                           '    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. '
                           'Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the '
                           'eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n'
                           '\n'
                           '    # Prepare the finite field characteristic (2^p - 1), this also represent the '
                           'maximum possible value in this field\n'
                           "    root_charac = 2 # we're in GF(2)\n"
                           '    field_charac = int(root_charac**c_exp - 1)\n'
                           '    field_charac_next = int(root_charac**(c_exp+1) - 1)\n'
                           '\n'
                           '    prim_candidates = []\n'
                           '    if fast_primes:\n'
                           '        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime '
                           'polynomials and check later if they really are irreducible\n'
                           '        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter '
                           'out too small primes\n'
                           '    else:\n'
                           '        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try '
                           'each possible prime polynomial, but skip even numbers (because divisible by 2 so '
                           'necessarily not irreducible)\n'
                           '\n'
                           '    # Start of the main loop\n'
                           '    correct_primes = []\n'
                           '    for prim in prim_candidates: # try potential candidates primitive irreducible '
                           'polys\n'
                           '        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was '
                           'already generated in the field (value at index x is set to 1) or not (set to 0 by '
                           'default)\n'
                           '        conflict = False # flag to know if there was at least one conflict\n'
                           '\n'
                           '        # Second loop, build the whole Galois Field\n'
                           '        x = 1\n'
                           '        for i in xrange(field_charac):\n'
                           '            # Compute the next value in the field (ie, the next power of '
                           'alpha/generator)\n'
                           '            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '            # Rejection criterion: if the value overflowed (above field_charac) or is '
                           'a duplicate of a previously generated power of alpha, then we reject this polynomial '
                           '(not prime)\n'
                           '            if x > field_charac or seen[x] == 1:\n'
                           '                conflict = True\n'
                           '                break\n'
                           '            # Else we flag this value as seen (to maybe detect future duplicates), and '
                           'we continue onto the next power of alpha\n'
                           '            else:\n'
                           '                seen[x] = 1\n'
                           '\n'
                           "        # End of the second loop: if there's no conflict (no overflow nor duplicated "
                           'value), this is a prime polynomial!\n'
                           '        if not conflict: \n'
                           '            correct_primes.append(prim)\n'
                           '            if single: return prim\n'
                           '\n'
                           '    # Return the list of all prime polynomials\n'
                           '    return correct_primes # you can use the following to print the hexadecimal '
                           'representation of each prime polynomial: print [hex(i) for i in correct_primes]\n'
                           '\n'
                           'def init_tables(prim=0x11d, generator=2, c_exp=8):\n'
                           "    '''Precompute the logarithm and anti-log tables for faster computation later, "
                           'using the provided primitive polynomial.\n'
                           '    These tables are used for multiplication/division since addition/substraction are '
                           'simple XOR operations inside GF of characteristic 2.\n'
                           '    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any '
                           'number b (the base or generator of the logarithm), then we can use any number b to '
                           'precompute logarithm and anti-log (exponentiation) tables to use for multiplying two '
                           'numbers x and y.\n'
                           "    That's why when we use a different base/generator number, the log and anti-log "
                           'tables are drastically different, but the resulting computations are the same given '
                           'any such tables.\n'
                           '    For more infos, see '
                           'https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n'
                           "    '''\n"
                           '    # generator is the generator number (the "increment" that will be used to walk '
                           'through the field by multiplication, this must be a prime number). This is basically '
                           'the base of the logarithm/anti-log tables. Also often noted "alpha" in academic '
                           'books.\n'
                           '    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it '
                           "can't represented as the product of two smaller polynomials). It's a polynomial in the "
                           "binary sense: each bit is a coefficient, but in fact it's an integer between "
                           'field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial '
                           'will be used to reduce the overflows back into the range of the Galois Field without '
                           'duplicating values (all values should be unique). See the function find_prime_polys() '
                           'and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n'
                           "    # note that the choice of generator or prime polynomial doesn't matter very much: "
                           'any two finite fields of size p^n have identical structure, even if they give the '
                           'individual elements different names (ie, the coefficients of the codeword will be '
                           'different, but the final result will be the same: you can always correct as many '
                           "errors/erasures with any choice for those parameters). That's why it makes sense to "
                           'refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as '
                           'one concept: GF(p^n). It can however impact sensibly the speed (because some '
                           'parameters will generate sparser tables).\n'
                           "    # c_exp is the exponent for the field's characteristic GF(2^c_exp)\n"
                           '\n'
                           '    # Redefine _bytearray() in case we need to support integers or messages of length '
                           '> 256\n'
                           '    global _bytearray\n'
                           '    if c_exp <= 8:\n'
                           '        _bytearray = bytearray\n'
                           '    else:\n'
                           '        from array import array\n'
                           '        def _bytearray(obj = 0, encoding = "latin-1"):\n'
                           "            '''Fake bytearray replacement, supporting int values above 255'''\n"
                           '            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '            if isinstance(obj, str):  # obj is a string, convert to list of ints\n'
                           '                obj = obj.encode(encoding)\n'
                           '                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n'
                           '                    obj = [ord(chr) for chr in obj]\n'
                           '                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need '
                           "to convert to int for array.array('i', obj)\n"
                           '                    obj = [int(chr) for chr in obj]\n'
                           '                else:\n'
                           '                    raise(ValueError, "Type of object not recognized!")\n'
                           '            elif isinstance(obj, int):  # compatibility with list preallocation '
                           'bytearray(int)\n'
                           '                obj = [0] * obj\n'
                           '            elif isinstance(obj, bytes):\n'
                           '                obj = [int(b) for b in obj]\n'
                           "            # Else obj is a list of int, it's ok\n"
                           '            return array("i", obj)\n'
                           '\n'
                           '    # Init global tables\n'
                           '    global gf_exp, gf_log, field_charac\n'
                           '    field_charac = int(2**c_exp - 1)\n'
                           '    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first '
                           'two elements will always be [GF256int(1), generator]\n'
                           '    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus '
                           'unused\n'
                           '\n'
                           '    # For each possible value in the galois field 2^8, we will pre-compute the '
                           'logarithm and anti-logarithm (exponential) of this value\n'
                           '    # To do that, we generate the Galois Field F(2^p) by building a list starting with '
                           'the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, '
                           'α^2, ..., α^(p-1).\n'
                           '    x = 1\n'
                           '    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 '
                           'because of modulo: g^255==g^0 but either way, this does not change the later outputs '
                           '(ie, the ecc symbols will be the same either way)\n'
                           '        gf_exp[i] = x # compute anti-log for this value and store it in a table\n'
                           '        gf_log[x] = i # compute log at the same time\n'
                           '        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '        # If you use only generator==2 or a power of 2, you can use the following '
                           'which is faster than gf_mult_noLUT():\n'
                           '        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power '
                           'of 2^y)\n'
                           '        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n'
                           '            #x ^= prim # substract the primary polynomial to the current value '
                           '(instead of 255, so that we get a unique set made of coprime numbers), this is the '
                           'core of the tables generation\n'
                           '\n'
                           "    # Optimization: double the size of the anti-log table so that we don't need to mod "
                           '255 to stay inside the bounds (because we will mainly use this table for the '
                           'multiplication of two GF numbers, no more).\n'
                           '    for i in xrange(field_charac, field_charac * 2):\n'
                           '        gf_exp[i] = gf_exp[i - field_charac]\n'
                           '\n'
                           '    return [gf_log, gf_exp, field_charac]\n'
                           '\n'
                           'def gf_add(x, y):\n'
                           '    return x ^ y\n'
                           '\n'
                           'def gf_sub(x, y):\n'
                           '    return x ^ y # in binary galois field, substraction is just the same as addition '
                           '(since we mod 2)\n'
                           '\n'
                           'def gf_neg(x):\n'
                           '    return x\n'
                           '\n'
                           'def gf_inverse(x):\n'
                           '    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n'
                           '\n'
                           'def gf_mul(x, y):\n'
                           '    if x == 0 or y == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_div(x, y):\n'
                           '    if y == 0:\n'
                           '        raise ZeroDivisionError()\n'
                           '    if x == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_pow(x, power):\n'
                           '    return gf_exp[(gf_log[x] * power) % field_charac]\n'
                           '\n'
                           'def gf_mult_noLUT_slow(x, y, prim=0):\n'
                           "    '''Multiplication in Galois Fields without using a precomputed look-up table (and "
                           "thus it's slower) by using the standard carry-less multiplication + modular reduction "
                           "using an irreducible prime polynomial.'''\n"
                           '\n'
                           '    ### Define bitwise carry-less operations as inner functions ###\n'
                           '    def cl_mult(x,y):\n'
                           "        '''Bitwise carry-less multiplication on integers'''\n"
                           '        z = 0\n'
                           '        i = 0\n'
                           '        while (y>>i) > 0:\n'
                           '            if y & (1<<i):\n'
                           '                z ^= x<<i\n'
                           '            i += 1\n'
                           '        return z\n'
                           '\n'
                           '    def bit_length(n):\n'
                           "        '''Compute the position of the most significant bit (1) of an integer. "
                           "Equivalent to int.bit_length()'''\n"
                           '        bits = 0\n'
                           '        while n >> bits: bits += 1\n'
                           '        return bits\n'
                           ' \n'
                           '    def cl_div(dividend, divisor=None):\n'
                           "        '''Bitwise carry-less long division on integers and returns the remainder'''\n"
                           '        # Compute the position of the most significant bit for each integers\n'
                           '        dl1 = bit_length(dividend)\n'
                           '        dl2 = bit_length(divisor)\n'
                           '        # If the dividend is smaller than the divisor, just exit\n'
                           '        if dl1 < dl2:\n'
                           '            return dividend\n'
                           '        # Else, align the most significant 1 of the divisor to the most significant 1 '
                           'of the dividend (by shifting the divisor)\n'
                           '        for i in xrange(dl1-dl2,-1,-1):\n'
                           '            # Check that the dividend is divisible (useless for the first iteration '
                           'but important for the next ones)\n'
                           '            if dividend & (1 << i+dl2-1):\n'
                           '                # If divisible, then shift the divisor to align the most significant '
                           'bits and XOR (carry-less substraction)\n'
                           '                dividend ^= divisor << i\n'
                           '        return dividend\n'
                           ' \n'
                           '    ### Main GF multiplication routine ###\n'
                           ' \n'
                           '    # Multiply the gf numbers\n'
                           '    result = cl_mult(x,y)\n'
                           '    # Then do a modular reduction (ie, remainder from the division) with an '
                           'irreducible primitive polynomial so that it stays inside GF bounds\n'
                           '    if prim > 0:\n'
                           '        result = cl_div(result, prim)\n'
                           ' \n'
                           '    return result\n'
                           '\n'
                           'def gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n'
                           "    '''Galois Field integer multiplication using Russian Peasant Multiplication "
                           'algorithm (faster than the standard multiplication + modular reduction).\n'
                           '    If prim is 0 and carryless=False, then the function produces the result for a '
                           'standard integers multiplication (no carry-less arithmetics nor modular '
                           "reduction).'''\n"
                           '    r = 0\n'
                           '    while y: # while y is above 0\n'
                           '        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the '
                           "corresponding x to r (the sum of all x's corresponding to odd y's will give the final "
                           "product). Note that since we're in GF(2), the addition is in fact an XOR (very "
                           'important because in GF(2) the multiplication and additions are carry-less, thus it '
                           'changes the result!).\n'
                           '        y = y >> 1 # equivalent to y // 2\n'
                           '        x = x << 1 # equivalent to x*2\n'
                           '        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 '
                           'then apply modular reduction using the primitive polynomial (we just substract, but '
                           'since the primitive number can be above 256 then we directly XOR).\n'
                           '\n'
                           '    return r\n'
                           '\n'
                           '\n'
                           '################### GALOIS FIELD POLYNOMIALS MATHS ###################\n'
                           '\n'
                           'def gf_poly_scale(p, x):\n'
                           '    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n'
                           '\n'
                           'def gf_poly_add(p, q):\n'
                           '    r = _bytearray( max(len(p), len(q)) )\n'
                           '    r[len(r)-len(p):len(r)] = p\n'
                           '    #for i in xrange(len(p)):\n'
                           '        #r[i + len(r) - len(p)] = p[i]\n'
                           '    for i in xrange(len(q)):\n'
                           '        r[i + len(r) - len(q)] ^= q[i]\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul(p, q):\n'
                           "    '''Multiply two polynomials, inside Galois Field (but the procedure is generic). "
                           "Optimized function by precomputation of log.'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Precompute the logarithm of p\n'
                           '    lp = [gf_log[p[i]] for i in xrange(len(p))]\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        qj = q[j] # optimization: load the coefficient once\n'
                           '        if qj != 0: # log(0) is undefined, we need to check that\n'
                           '            lq = gf_log[qj] # Optimization: precache the logarithm of the current '
                           'coefficient of q\n'
                           '            for i in xrange(len(p)):\n'
                           '                if p[i] != 0: # log(0) is undefined, need to check that...\n'
                           '                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = '
                           'gf_add(r[i+j], gf_mul(p[i], q[j]))\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials '
                           "without precomputation, but thus it's slower\n"
                           "    '''Multiply two polynomials, inside Galois Field'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        for i in xrange(len(p)):\n'
                           '            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], '
                           "gf_mul(p[i], q[j])) -- you can see it's your usual polynomial multiplication\n"
                           '    return r\n'
                           '\n'
                           'def gf_poly_neg(poly):\n'
                           "    '''Returns the polynomial with all coefficients negated. In GF(2^p), negation does "
                           "not change the coefficient, so we return the polynomial as-is.'''\n"
                           '    return poly\n'
                           '\n'
                           'def gf_poly_div(dividend, divisor):\n'
                           "    '''Fast polynomial division by using Extended Synthetic Division and optimized for "
                           "GF(2^p) computations (doesn't work with standard polynomials outside of this galois "
                           "field).'''\n"
                           '    # CAUTION: this function expects polynomials to follow the opposite convention at '
                           'decoding: the terms must go from the biggest to lowest degree (while most other '
                           'functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, '
                           '2, 1], NOT [1, 2, 5]\n'
                           '\n'
                           '    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the '
                           'ecc bytes will be computed\n'
                           '    #normalizer = divisor[0] # precomputing for performance\n'
                           '    for i in xrange(len(dividend) - (len(divisor)-1)):\n'
                           '        #msg_out[i] /= normalizer # for general polynomial division (when polynomials '
                           'are non-monic), the usual way of using synthetic division is to divide the divisor '
                           'g(x) with its leading coefficient (call it a). In this implementation, this means:we '
                           'need to compute: coef = msg_out[i] / gen[0]. For more infos, see '
                           'http://en.wikipedia.org/wiki/Synthetic_division\n'
                           '        coef = msg_out[i] # precaching\n'
                           '        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly '
                           "(and it's also a good optimization). In fact if you remove it, it should still work "
                           "because gf_mul() will take care of the condition. But it's still a good practice to "
                           'put the condition here.\n'
                           '            for j in xrange(1, len(divisor)): # in synthetic division, we always skip '
                           "the first coefficient of the divisior, because it's only used to normalize the "
                           'dividend coefficient\n'
                           '                if divisor[j] != 0: # log(0) is undefined\n'
                           '                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the '
                           'more mathematically correct (but xoring directly is faster): msg_out[i + j] += '
                           '-divisor[j] * coef\n'
                           '\n'
                           '    # The resulting msg_out contains both the quotient and the remainder, the '
                           'remainder being the size of the divisor (the remainder has necessarily the same degree '
                           "as the divisor -- not length but degree == length-1 -- since it's what we couldn't "
                           'divide from the dividend), so we compute the index where this separation is, and '
                           'return the quotient and remainder.\n'
                           '    separator = -(len(divisor)-1)\n'
                           '    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n'
                           '\n'
                           'def gf_poly_square(poly):  # pragma: no cover\n'
                           "    '''Linear time implementation of polynomial squaring. For details, see paper: "
                           '"A fast software implementation for arithmetic operations in GF (2n)". De Win, E., '
                           'Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In '
                           "Advances in Cryptology - Asiacrypt'96 (pp. 65-76). Springer Berlin Heidelberg.'''\n"
                           '    length = len(poly)\n'
                           '    out = _bytearray(2*length - 1)\n'
                           '    for i in xrange(length-1):\n'
                           '        p = poly[i]\n'
                           '        k = 2*i\n'
                           '        if p != 0:\n'
                           '            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo '
                           '(2^r)-1 since gf_exp is duplicated up to 510.\n'
                           '            out[k] = gf_exp[2*gf_log[p]]\n'
                           '        #else: # not necessary since the output is already initialized to an array of '
                           '0\n'
                           '            #out[k] = 0\n'
                           '    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n'
                           '    if out[0] == 0: out[0] = 2*poly[1] - 1\n'
                           '    return out\n'
                           '\n'
                           'def gf_poly_eval(poly, x):\n'
                           "    '''Evaluates a polynomial in GF(2^p) given the value for x. This is based on "
                           "Horner's scheme for maximum efficiency.'''\n"
                           '    y = poly[0]\n'
                           '    for i in xrange(1, len(poly)):\n'
                           '        y = gf_mul(y, x) ^ poly[i]\n'
                           '    return y\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON ENCODING ###################\n'
                           '\n'
                           'def rs_generator_poly(nsym, fcr=0, generator=2):\n'
                           "    '''Generate an irreducible generator polynomial (necessary to encode a message "
                           "into Reed-Solomon)'''\n"
                           '    g = _bytearray([1])\n'
                           '    for i in xrange(nsym):\n'
                           '        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n'
                           '    return g\n'
                           '\n'
                           'def rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n'
                           "    '''Generate all irreducible generator polynomials up to max_nsym (usually you can "
                           'use n, the length of the message+ecc). Very useful to reduce processing time if you '
                           "want to encode using variable schemes and nsym rates.'''\n"
                           '    g_all = {}\n'
                           '    g_all[0] = g_all[1] = _bytearray([1])\n'
                           '    for nsym in xrange(max_nsym):\n'
                           '        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n'
                           '    return g_all\n'
                           '\n'
                           'def rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Simple Reed-Solomon encoding (mainly an example for you to understand how it "
                           "works, because it's slower than the inlined function below)'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    # Pad the message, then divide it by the irreducible generator polynomial\n'
                           '    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n'
                           '    # The remainder is our RS code! Just append it to our original message to get our '
                           'full codeword (this represents a polynomial of max 256 terms)\n'
                           '    msg_out = msg_in + remainder\n'
                           '    # Return the codeword\n'
                           '    return msg_out\n'
                           '\n'
                           'def rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Reed-Solomon main encoding function, using polynomial division (Extended "
                           'Synthetic Division, the fastest algorithm available to my knowledge), better explained '
                           "at http://research.swtch.com/field'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    msg_in = _bytearray(msg_in)\n'
                           '    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the '
                           'values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc '
                           'symbols).\n'
                           '\n'
                           '    # Precompute the logarithm of every items in the generator\n'
                           '    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n'
                           '\n'
                           '    # Extended synthetic division main loop\n'
                           '    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is '
                           'about 2x faster)\n'
                           '    for i in xrange(len(msg_in)):\n'
                           "        coef = msg_out[i] # Note that it's msg_out here, not msg_in. Thus, we reuse "
                           'the updated value at each iteration (this is how Synthetic Division works: instead of '
                           'storing in a temporary register the intermediate values, we directly commit them to '
                           'the output).\n'
                           '        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial '
                           'division (when polynomials are non-monic), the usual way of using synthetic division '
                           'is to divide the divisor g(x) with its leading coefficient (call it a). In this '
                           'implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n'
                           '        if coef != 0: # log(0) is undefined, so we need to manually check for this '
                           "case. There's no need to check the divisor here because we know it can't be 0 since we "
                           'generated it.\n'
                           '            lcoef = gf_log[coef] # precaching\n'
                           '\n'
                           '            for j in xrange(1, len(gen)): # in synthetic division, we always skip the '
                           "first coefficient of the divisior, because it's only used to normalize the dividend "
                           'coefficient (which is here useless since the divisor, the generator polynomial, is '
                           'always monic)\n'
                           '                #if gen[j] != 0: # log(0) is undefined so we need to check that, but '
                           "it slow things down in fact and it's useless in our case (reed-solomon encoding) since "
                           'we know that all coefficients in the generator are not 0\n'
                           '                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent '
                           'to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we '
                           "are in GF256, it's equivalent to an addition and to an XOR). In other words, this is "
                           'simply a "multiply-accumulate operation"\n'
                           '\n'
                           '    # Recopy the original message bytes (overwrites the part where the quotient was '
                           'computed)\n'
                           '    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is '
                           'msg_in padded with [0]*nsym\n'
                           '    return msg_out\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON DECODING ###################\n'
                           '\n'
                           'def rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Given the received codeword msg and the number of error correcting symbols "
                           '(nsym), computes the syndromes polynomial.\n'
                           "    Mathematically, it's essentially equivalent to a Fourrier Transform (Chien search "
                           'being the inverse).\n'
                           "    '''\n"
                           '    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). '
                           'This effectively shifts the syndrome, and will shift every computations depending on '
                           'the syndromes (such as the errors locator polynomial, errors evaluator polynomial, '
                           'etc. but not the errors positions).\n'
                           '    # This is not necessary as anyway syndromes are defined such as there are only '
                           'non-zero coefficients (the only 0 is the shift of the constant here) and subsequent '
                           'computations will/must account for the shift by skipping the first iteration (eg, the '
                           'often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt '
                           'every subsequent computations to start from 0 instead of 1.\n'
                           '    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n'
                           '\n'
                           'def rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list '
                           'of the positions of the errors/erasures/errata\n'
                           "    '''Forney algorithm, computes the values (error magnitude) to correct the input "
                           "message.'''\n"
                           '    global field_charac\n'
                           '    msg = _bytearray(msg_in)\n'
                           '    # calculate errata locator polynomial to correct both errors and erasures (by '
                           'combining the errors positions given by the error locator polynomial found by BM with '
                           'the erasures positions given by caller)\n'
                           '    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to '
                           'coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it '
                           'will become [len(msg)-1, len(msg)-2, len(msg) -3])\n'
                           '    err_loc = rs_find_errata_locator(coef_pos, generator)\n'
                           '    # calculate errata evaluator polynomial (often called Omega or Gamma in academic '
                           'papers)\n'
                           '    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n'
                           '\n'
                           '    # Second part of Chien search to get the error location polynomial X from the '
                           'error positions in err_pos (the roots of the error locator polynomial, ie, where it '
                           'evaluates to 0)\n'
                           '    X = [] # will store the position of the errors\n'
                           '    for i in xrange(len(coef_pos)):\n'
                           '        l = field_charac - coef_pos[i]\n'
                           '        X.append( gf_pow(generator, -l) )\n'
                           '\n'
                           '    # Forney algorithm: compute the magnitudes\n'
                           '    E = _bytearray(len(msg)) # will store the values that need to be corrected '
                           '(substracted) to the message containing errors. This is sometimes called the error '
                           'magnitude polynomial.\n'
                           '    Xlength = len(X)\n'
                           '    for i, Xi in enumerate(X):\n'
                           '\n'
                           '        Xi_inv = gf_inverse(Xi)\n'
                           '\n'
                           '        # Compute the formal derivative of the error locator polynomial (see Blahut, '
                           'Algebraic codes for data transmission, pp 196-197).\n'
                           '        # the formal derivative of the errata locator is used as the denominator of '
                           'the Forney Algorithm, which simply says that the ith error value is given by '
                           'error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See '
                           'Blahut, Algebraic codes for data transmission, pp 196-197.\n'
                           '        err_loc_prime_tmp = []\n'
                           '        for j in xrange(Xlength):\n'
                           '            if j != i:\n'
                           '                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n'
                           '        # compute the product, which is the denominator of the Forney algorithm '
                           '(errata locator derivative)\n'
                           '        err_loc_prime = 1\n'
                           '        for coef in err_loc_prime_tmp:\n'
                           '            err_loc_prime = gf_mul(err_loc_prime, coef)\n'
                           '        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, '
                           '1)\n'
                           '\n'
                           '        # Test if we could find the errata locator, else we raise an Exception '
                           '(because else since we divide y by err_loc_prime to compute the magnitude, we will get '
                           'a ZeroDivisionError exception otherwise)\n'
                           '        if err_loc_prime == 0:\n'
                           '            raise ReedSolomonError("Decoding failed: Forney algorithm could not '
                           'properly detect where the errors are located (errata locator prime is 0).")\n'
                           '\n'
                           '        # Compute y (evaluation of the errata evaluator polynomial)\n'
                           '        # This is a more faithful translation of the theoretical equation contrary to '
                           'the old forney method. Here it is exactly copy/pasted from the included presentation '
                           'decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) '
                           "(in the paper it's for j in s, but it's useless when len(X) < s because we compute "
                           'neutral terms 1 for nothing, and wrong when correcting more than s erasures or '
                           'erasures+errors since it prevents computing all required terms).\n'
                           '        # Thus here this method works with erasures too because firstly we fixed the '
                           "equation to be like the theoretical one (don't know why it was modified in "
                           "_old_forney(), if it's an optimization, it doesn't enhance anything), and secondly "
                           'because we removed the product bound on s, which prevented computing errors and '
                           'erasures above the s=(n-k)//2 bound.\n'
                           '        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm '
                           '(errata evaluator evaluated)\n'
                           '        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n'
                           '        \n'
                           '        # Compute the magnitude\n'
                           '        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, '
                           'calculated by the Forney algorithm (an equation in fact): dividing the errata '
                           'evaluator with the errata locator derivative gives us the errata magnitude (ie, value '
                           'to repair) the ith symbol\n'
                           '        E[err_pos[i]] = magnitude # store the magnitude for this error into the '
                           'magnitude polynomial\n'
                           '\n'
                           '    # Apply the correction of values to get our message corrected! (note that the ecc '
                           'bytes also gets corrected!)\n'
                           "    # (this isn't the Forney algorithm, we just apply the result of decoding here)\n"
                           '    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct '
                           'message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is '
                           "replaced by XOR since it's equivalent in GF(2^p)). So in fact here we substract from "
                           'the received message the errors magnitude, which logically corrects the value to what '
                           'it should be.\n'
                           '    return msg\n'
                           '\n'
                           'def rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n'
                           "    '''Find error/errata locator and evaluator polynomials with Berlekamp-Massey "
                           "algorithm'''\n"
                           '    # The idea is that BM will iteratively estimate the error locator polynomial.\n'
                           '    # To do this, it will compute a Discrepancy term called Delta, which will tell us '
                           'if the error locator polynomial needs an update or not\n'
                           "    # (hence why it's called discrepancy: it tells us when we are getting off board "
                           'from the correct value).\n'
                           '\n'
                           '    # Init the polynomials\n'
                           '    if erase_loc: # if the erasure locator polynomial is supplied, we init with its '
                           'value, so that we include erasures in the final locator polynomial\n'
                           '        err_loc = _bytearray(erase_loc)\n'
                           '        old_loc = _bytearray(erase_loc)\n'
                           '    else:\n'
                           '        err_loc = _bytearray([1]) # This is the main variable we want to fill, also '
                           'called Sigma in other notations or more formally the errors/errata locator '
                           'polynomial.\n'
                           '        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the '
                           'errata locator polynomial of the previous iteration in order to update other necessary '
                           'variables.\n'
                           '    #L = 0 # update flag variable, not needed here because we use an alternative '
                           'equivalent way of checking if update is needed (but using the flag could potentially '
                           'be faster depending on if using length(list) is taking linear time in your language, '
                           "here in Python it's constant so it's as fast.\n"
                           '\n'
                           '    # Fix the syndrome shifting: when computing the syndrome, some implementations may '
                           'prepend a 0 coefficient for the lowest degree term (the constant). This is a case of '
                           'syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I '
                           "don't know what purpose serves this shifting). If that's the case, then we need to "
                           'account for the syndrome shifting when we use the syndrome such as inside BM, by '
                           'skipping those prepended coefficients.\n'
                           '    # Another way to detect the shifting is to detect the 0 coefficients: by '
                           'definition, a syndrome does not contain any 0 coefficient (except if there are no '
                           "errors/erasures, in this case they are all 0). This however doesn't work with the "
                           'modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, '
                           'leaving only the coefficients corresponding to errors.\n'
                           '    synd_shift = 0\n'
                           '    if len(synd) > nsym: synd_shift = len(synd) - nsym\n'
                           '\n'
                           '    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), '
                           'except when you input a partial erase_loc and using the full syndrome instead of the '
                           'Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail '
                           'badly with IndexError).\n'
                           '        if erase_loc: # if an erasures locator polynomial was provided to init the '
                           'errors locator polynomial, then we must skip the FIRST erase_count iterations (not the '
                           'last iterations, this is very important!)\n'
                           '            K = erase_count+i+synd_shift\n'
                           "        else: # if erasures locator is not provided, then either there's no erasures "
                           "to account or we use the Forney syndromes, so we don't need to use erase_count nor "
                           'erase_loc (the erasures have been trimmed out of the Forney syndromes).\n'
                           '            K = i+synd_shift\n'
                           '\n'
                           '        # Compute the discrepancy Delta\n'
                           '        # Here is the close-to-the-books operation to compute the discrepancy Delta: '
                           "it's a simple polynomial multiplication of error locator with the syndromes, and then "
                           'we get the Kth element.\n'
                           '        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be '
                           "gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it's not "
                           'absolutely necessary to correctly decode.\n'
                           "        # But this can be optimized: since we only need the Kth element, we don't need "
                           'to compute the polynomial multiplication for any other element but the Kth. Thus to '
                           'optimize, we compute the polymul only at the item we need, skipping the rest (avoiding '
                           'a nested loop, thus we are linear time instead of quadratic).\n'
                           '        # This optimization is actually described in several figures of the book '
                           '"Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge '
                           'university press.\n'
                           '        delta = synd[K]\n'
                           '        for j in xrange(1, len(err_loc)):\n'
                           '            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called '
                           'discrepancy. Here we do a partial polynomial multiplication (ie, we compute the '
                           'polynomial multiplication only for the term of degree K). Should be equivalent to '
                           'brownanrs.polynomial.mul_at().\n'
                           '        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n'
                           '\n'
                           '        # Shift polynomials to compute the next degree\n'
                           '        old_loc = old_loc + _bytearray([0])\n'
                           '\n'
                           '        # Iteratively estimate the errata locator and evaluator polynomials\n'
                           "        if delta != 0: # Update only if there's a discrepancy\n"
                           '            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined '
                           'because rule A just says that we skip any modification for this iteration)\n'
                           '            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as '
                           'long as L is correctly computed\n'
                           '                # Computing errata locator polynomial Sigma\n'
                           '                new_loc = gf_poly_scale(old_loc, delta)\n'
                           '                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we '
                           'are doing err_loc * 1/delta = err_loc // delta\n'
                           '                err_loc = new_loc\n'
                           '                # Update the update flag\n'
                           "                #L = K - L # the update flag L is tricky: in Blahut's schema, it's "
                           'mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this '
                           'function, if you forgot to do `- erase_count` it would lead to correcting only '
                           '2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this '
                           'latest draft, this will lead to a wrong decoding in some cases where it should '
                           'correctly decode! Thus you should try with and without `- erase_count` to update L on '
                           'your own implementation and see which one works OK without producing wrong decoding '
                           'failures.\n'
                           '\n'
                           '            # Update with the discrepancy\n'
                           '            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n'
                           '\n'
                           "    # Check if the result is correct, that there's not too many errors to correct\n"
                           '    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, '
                           'else errs will not be of the correct size\n'
                           '    errs = len(err_loc) - 1\n'
                           '    if (errs-erase_count) * 2 + erase_count > nsym:\n'
                           '        raise ReedSolomonError("Too many errors to correct")\n'
                           '\n'
                           '    return err_loc\n'
                           '\n'
                           'def rs_find_errata_locator(e_pos, generator=2):\n'
                           "    '''Compute the erasures/errors/errata locator polynomial from the "
                           'erasures/errors/errata positions (the positions must be relative to the x coefficient, '
                           'eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being '
                           'the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients '
                           'are reversed since the ecc characters are placed as the first coefficients of the '
                           'polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] '
                           "= erasures_loc to be specified as an argument.'''\n"
                           '    # See: '
                           'http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf '
                           'and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of '
                           'Research and development 23.3 (1979): 299-315. '
                           'http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and '
                           'also a MatLab implementation here: '
                           'http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n'
                           '    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the '
                           'multiplication starts correctly without nulling any term\n'
                           '    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for '
                           'i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in '
                           "this library it's gf(3)). To generate c*x where c is a constant, we simply generate a "
                           'Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient '
                           'for x^1.\n'
                           '    for i in e_pos:\n'
                           '        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, '
                           'i), 0]) )\n'
                           '    return e_loc\n'
                           '\n'
                           'def rs_find_error_evaluator(synd, err_loc, nsym):\n'
                           "    '''Compute the error (or erasures if you supply sigma=erasures locator polynomial, "
                           'or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata '
                           'locator Sigma. Omega is already computed at the same time as Sigma inside the '
                           'Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute '
                           'Omega afterwards using this method, or just ensure that Omega computed by BM is '
                           "correct given Sigma.'''\n"
                           '    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n'
                           '    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # '
                           'first multiply syndromes * errata_locator, then do a polynomial division to truncate '
                           'the polynomial to the required length\n'
                           '\n'
                           '    # Faster way that is equivalent\n'
                           '    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the '
                           'errata locator polynomial\n'
                           '    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of '
                           'the length we want, which is equivalent to slicing the list (which represents the '
                           'polynomial)\n'
                           '\n'
                           '    return remainder\n'
                           '\n'
                           'def rs_find_errors(err_loc, nmess, generator=2):\n'
                           "    '''Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce "
                           "trial, this is a sort of Chien's search (but less efficient, Chien's search is a way "
                           "to evaluate the polynomial such that each evaluation only takes constant time).'''\n"
                           '    # nmess = length of whole codeword (message + ecc symbols)\n'
                           '    errs = len(err_loc) - 1\n'
                           '    err_pos = []\n'
                           '    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here '
                           'we optimize to just check the interesting symbols\n'
                           "        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It's a 0? Bingo, it's a "
                           'root of the error locator polynomial, in other terms this is the location of an error\n'
                           '            err_pos.append(nmess - 1 - i)\n'
                           '    # Sanity check: the number of errors/errata positions found should be exactly the '
                           'same as the length of the errata locator polynomial\n'
                           '    if len(err_pos) != errs:\n'
                           '        # TODO: to decode messages+ecc with length n > 255, we may try to use a '
                           'bruteforce approach: the correct positions ARE in the final array j, but the problem '
                           "is because we are above the Galois Field's range, there is a wraparound so that for "
                           'example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because '
                           "258 % 255 == 3, same for the other values), so we can't discriminate. The issue is "
                           'that fixing any errs_nb errors among those will always give a correct output message '
                           '(in the sense that the syndrome will be all 0), so we may not even be able to check if '
                           "that's correct or not, so I'm not sure the bruteforce approach may even be possible.\n"
                           '        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the '
                           'errata locator polynomial!")\n'
                           '    return err_pos\n'
                           '\n'
                           'def rs_forney_syndromes(synd, pos, nmess, generator=2):\n'
                           '    # Compute Forney syndromes, which computes a modified syndromes to compute only '
                           'errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which '
                           'allows to correct the message based on the location of errors.\n'
                           '    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree '
                           'positions (instead of the erasures positions)\n'
                           '\n'
                           '    # Optimized method, all operations are inlined\n'
                           '    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is '
                           'always 0 by definition\n'
                           '    for i in xrange(len(pos)):\n'
                           '        x = gf_pow(generator, erase_pos_reversed[i])\n'
                           '        for j in xrange(len(fsynd) - 1):\n'
                           '            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n'
                           "        #fsynd.pop() # useless? it doesn't change the results of computations to leave "
                           'it there\n'
                           '\n'
                           '    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * '
                           'synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as '
                           'many books do not even mention it (and it works without trimming)\n'
                           '    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A '
                           'single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, '
                           "IEEE International Conference on ICASSP'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n"
                           '    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # '
                           'computing the erasures locator polynomial\n'
                           '    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome '
                           'to get the untrimmed forney syndrome\n'
                           '    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are '
                           'useless. Seems to be not necessary, but this reduces the computation time later in BM '
                           "(thus it's an optimization).\n"
                           '\n'
                           '    return fsynd\n'
                           '\n'
                           'def rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        # Note that it is in fact possible to encode/decode messages that are longer '
                           'than field_charac, but because this will be above the field, this will generate more '
                           'error positions during Chien Search than it should, because this will generate '
                           "duplicate values, which should normally be prevented thank's to the prime polynomial "
                           "reduction (eg, because it can't discriminate between error at position 1 or 256, both "
                           "being exactly equal under galois field 2^8). So it's really not advised to do it, but "
                           "it's possible (but then you're not guaranted to be able to correct any error/erasure "
                           'on symbols with a position above the length of field_charac -- if you really need a '
                           'bigger message without chunking, then you should better enlarge c_exp so that you get '
                           'a bigger field).\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures to correct (beyond the Singleton bound)\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n'
                           '\n'
                           '    # Find errors locations\n'
                           '    if only_erasures:\n'
                           '        err_pos = []\n'
                           '    else:\n'
                           '        # compute the Forney syndromes, which hide the erasures from the original '
                           'syndrome (so that BM will just have to deal with errors, not erasures)\n'
                           '        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n'
                           '        # compute the error locator polynomial using Berlekamp-Massey\n'
                           '        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n'
                           '        # locate the message errors using Chien search (or bruteforce search)\n'
                           '        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n'
                           '        if err_pos is None:\n'
                           '            raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # Find errors values and apply them to correct the message\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # '
                           'note that we here use the original syndrome, not the forney syndrome (because we will '
                           'correct both errors and erasures, so we need the full syndrome)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function, without using the modified Forney "
                           "syndromes'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n'
                           '\n'
                           '    # prepare erasures locator and evaluator polynomials\n'
                           '    erase_loc = None\n'
                           '    #erase_eval = None\n'
                           '    erase_count = 0\n'
                           '    if erase_pos:\n'
                           '        erase_count = len(erase_pos)\n'
                           '        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n'
                           '        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n'
                           '        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, '
                           'len(erase_loc)-1)\n'
                           '\n'
                           '    # prepare errors/errata locator polynomial\n'
                           '    if only_erasures:\n'
                           '        err_loc = erase_loc[::-1]\n'
                           '        #err_eval = erase_eval[::-1]\n'
                           '    else:\n'
                           '        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, '
                           'erase_count=erase_count)\n'
                           '        err_loc = err_loc[::-1]\n'
                           '        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], '
                           'len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary '
                           'since we already compute it at the same time as the error locator poly in BM)\n'
                           '\n'
                           '    # locate the message errors\n'
                           '    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the '
                           'errata locator polynomial (ie: the positions of the errors/errata)\n'
                           '    if err_pos is None:\n'
                           '        raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_check(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Returns true if the message + ecc has no error of false otherwise (may not "
                           'always catch a wrong decoding or a wrong message, particularly if there are too many '
                           "errors -- above the Singleton bound --, but it usually does)'''\n"
                           '    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n'
                           '\n'
                           '\n'
                           '#===================================================================================================\n'
                           '# API\n'
                           '#===================================================================================================\n'
                           'class RSCodec(object):\n'
                           "    '''\n"
                           '    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to '
                           'encode a\n'
                           '    (byte)string to include the RS correction code, and pass such an encoded '
                           '(byte)string to\n'
                           '    ``decode`` to extract the original message (if the number of errors allows for '
                           'correct decoding).\n'
                           '    The ``nsym`` argument is the length of the correction code, and it determines the '
                           'number of\n'
                           '    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n'
                           "    '''\n"
                           "    '''\n"
                           '    Modifications by rotorgit 2/3/2015:\n'
                           '    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n'
                           '    different primitive polynomial and non-zero first consecutive root (fcr).\n'
                           '    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n'
                           '    the class; leaving them out will default for previous values (0 and\n'
                           '    0x11d)\n'
                           "    '''\n"
                           '\n'
                           '    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, '
                           'single_gen=True):\n'
                           "        '''Initialize the Reed-Solomon codec. Note that different parameters change "
                           'the internal values (the ecc symbols, look-up table values, etc) but not the output '
                           'result (whether your message can be repaired or not, there is no influence of the '
                           'parameters).\n'
                           '        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n'
                           '        nsize : maximum length of each chunk. If higher than 255, will use a higher '
                           "Galois Field, but the algorithm's complexity and computational cost will raise "
                           'quadratically...\n'
                           '        single_gen : if you want to use the same RSCodec for different nsym parameters '
                           '(but nsize the same), then set single_gen = False.\n'
                           "        '''\n"
                           '\n'
                           '        # Auto-setup if galois field or message length is different than default '
                           '(exponent 8)\n'
                           '        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois '
                           'field, we resize the galois field\n'
                           '            # Get the next closest power of two\n'
                           '            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), '
                           '2))\n'
                           '        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n'
                           '            prim = find_prime_polys(generator=generator, c_exp=c_exp, '
                           'fast_primes=True, single=True)\n'
                           '            if nsize == 255:  # resize chunk size if not set\n'
                           '                nsize = int(2**c_exp - 1)\n'
                           '        if nsym >= nsize:\n'
                           "            raise ValueError('ECC symbols must be strictly less than the total message "
                           "length (nsym < nsize).')\n"
                           '\n'
                           '        # Memorize variables\n'
                           '        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be '
                           'r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate '
                           'r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and '
                           '0.5% erasures (5 symbols out of 10).\n'
                           '        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols '
                           "after encoding, for the message alone it's nsize-nsym)\n"
                           '        self.fcr = fcr # first consecutive root, can be any value between 0 and '
                           '(2**c_exp)-1\n'
                           '        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to '
                           'find a prime poly\n'
                           '        self.generator = generator # generator integer, must be prime\n'
                           "        self.c_exp = c_exp # exponent of the field's characteristic. This both defines "
                           "the maximum value per symbol and the maximum length of one chunk. By default it's "
                           "GF(2^8), do not change if you're not sure what it means.\n"
                           '\n'
                           '        # Initialize the look-up tables for easy and quick multiplication/division\n'
                           '        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, '
                           'c_exp)\n'
                           '        # Precompute the generator polynomials\n'
                           '        if single_gen:\n'
                           '            self.gen = {}\n'
                           '            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n'
                           '        else:\n'
                           '            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n'
                           '\n'
                           '    def chunk(self, data, chunksize):\n'
                           "        '''Split a long message into chunks'''\n"
                           '        for i in xrange(0, len(data), chunksize):\n'
                           '            # Split the long message in a chunk\n'
                           '            chunk = data[i:i+chunksize]\n'
                           '            yield chunk\n'
                           '\n'
                           '    def encode(self, data, nsym=None):\n'
                           "        '''Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the "
                           "length of the message because we use chunking'''\n"
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        enc = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize - self.nsym):\n'
                           '            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, '
                           'generator=self.generator, gen=self.gen[nsym]))\n'
                           '        return enc\n'
                           '\n'
                           '    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n'
                           "        '''Repair a message, whatever its size is, by using chunking. May return a "
                           'wrong result if number of errors > nsym.\n'
                           '        Note that it returns a couple of vars: the repaired messages, and the repaired '
                           'messages+ecc (useful for checking).\n'
                           '        Usage: rmes, rmesecc = RSCodec.decode(data).\n'
                           "        '''\n"
                           '        # erase_pos is a list of positions where you know (or greatly suspect at '
                           "least) there is an erasure (ie, wrong character but you know it's at this position). "
                           'Just input the list of all positions you know there are errors, and this method will '
                           'automatically split the erasures positions to attach to the corresponding data chunk.\n'
                           '\n'
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        dec = _bytearray()\n'
                           '        dec_full = _bytearray()\n'
                           '        errata_pos_all = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            # Extract the erasures for this chunk\n'
                           '            e_pos = []\n'
                           '            if erase_pos:\n'
                           '                # First extract the erasures for this chunk (all erasures below the '
                           'maximum chunk length)\n'
                           '                e_pos = [x for x in erase_pos if x < self.nsize]\n'
                           '                # Then remove the extract erasures from the big list and also '
                           "decrement all subsequent positions values by nsize (the current chunk's size) so as to "
                           'prepare the correct alignment for the next iteration\n'
                           '                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n'
                           '            # Decode/repair this chunk!\n'
                           '            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n'
                           '            dec.extend(rmes)\n'
                           '            dec_full.extend(rmes+recc)\n'
                           '            errata_pos_all.extend(errata_pos)\n'
                           '        return dec, dec_full, errata_pos_all\n'
                           '\n'
                           '    def check(self, data, nsym=None):\n'
                           "        '''Check if a message+ecc stream is not corrupted (or fully repaired). Note: "
                           "may return a wrong result if number of errors > nsym.'''\n"
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        check = []\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            check.append(rs_check(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator))\n'
                           '        return check\n'
                           '\n'
                           '    def maxerrata(self, errors=None, erasures=None, verbose=False):\n'
                           "        '''Return the Singleton Bound for the current codec, which is the max number "
                           'of errata (errors and erasures) that the codec can decode/correct.\n'
                           '        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try '
                           'to raise an exception, but it may also not detect any problem with the message and '
                           'return 0 errors.\n'
                           '        Hence why you should use checksums if your goal is to detect errors (as '
                           'opposed to correcting them), as checksums have no bounds on the number of errors, the '
                           'only limitation being the probability of collisions.\n'
                           '        By default, return a tuple wth the maximum number of errors (2nd output) OR '
                           'erasures (2nd output) that can be corrected.\n'
                           '        If errors or erasures (not both) is specified as argument, computes the '
                           'remaining **simultaneous** correction capacity (eg, if errors specified, compute the '
                           'number of erasures that can be simultaneously corrected).\n'
                           "        Set verbose to True to get print a report.'''\n"
                           '        nsym = self.nsym\n'
                           '        # Compute the maximum number of errors OR erasures\n'
                           "        maxerrors = int(nsym/2)  # always floor the number, we can't correct half a "
                           "symbol, it's all or nothing\n"
                           '        maxerasures = nsym\n'
                           '        # Compute the maximum of simultaneous errors AND erasures\n'
                           '        if erasures is not None and erasures >= 0:\n'
                           '            # We know the erasures count, we want to know how many errors we can '
                           'correct simultaneously\n'
                           '            if erasures > maxerasures:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerrors = int((nsym-erasures)/2)\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (maxerrors, erasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return maxerrors, erasures\n'
                           '        if errors is not None and errors >= 0:\n'
                           '            # We know the errors count, we want to know how many erasures we can '
                           'correct simultaneously\n'
                           '            if errors > maxerrors:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerasures = int(nsym-(errors*2))\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (errors, maxerasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return errors, maxerasures\n'
                           '        # Return a tuple with the maximum number of errors and erasures (independently '
                           'corrected)\n'
                           '        if verbose:\n'
                           "            print('This codec can correct up to %i errors and %i erasures "
                           "independently' % (maxerrors, maxerasures))\n"
                           '        return maxerrors, maxerasures\n',
       'service': '"""ZMQ app boundary. All sockets and Engine methods belong to one thread."""\n'
                  'import queue\n'
                  'import threading\n'
                  'import time\n'
                  'import zmq\n'
                  'from .engine import Engine\n'
                  '\n'
                  '\n'
                  'class Service:\n'
                  '    def __init__(self, config, transmit, incoming=None, sensor=None, transport_tick=None):\n'
                  '        self.c=config;self.transmit=transmit;self.incoming=incoming or queue.Queue()\n'
                  '        '
                  'self.sensor=sensor;self.transport_tick=transport_tick;self.stop_event=threading.Event()\n'
                  '        self.ready=threading.Event();self.error=None;self.thread=None\n'
                  '\n'
                  '    def start(self):\n'
                  '        '
                  "self.thread=threading.Thread(target=self.run,name='radio-mac',daemon=True);self.thread.start()\n"
                  "        if not self.ready.wait(5):raise RuntimeError('Radio service did not start')\n"
                  '        if self.error:raise RuntimeError(str(self.error))\n'
                  '\n'
                  '    def stop(self):\n'
                  '        self.stop_event.set()\n'
                  '        if self.thread:self.thread.join(5)\n'
                  '\n'
                  '    def run(self):\n'
                  '        '
                  'context=zmq.Context();commands=context.socket(zmq.PULL);events=context.socket(zmq.PUSH)\n'
                  '        commands.setsockopt(zmq.MAXMSGSIZE,1024*1024)\n'
                  '        for s in (commands,events):s.setsockopt(zmq.LINGER,0)\n'
                  '        engine=None\n'
                  '        try:\n'
                  "            commands.bind('tcp://127.0.0.1:'+str(self.c['commands_port']))\n"
                  "            events.bind('tcp://127.0.0.1:'+str(self.c['events_port']))\n"
                  '            def emit(event):\n'
                  '                try:events.send_json(event,zmq.NOBLOCK)\n'
                  '                except zmq.Again:pass # Durable snapshot recovers message events on reconnect.\n'
                  '            engine=Engine(self.c,self.transmit,emit)\n'
                  '            self.ready.set()\n'
                  '            while not self.stop_event.is_set():\n'
                  '                if self.transport_tick:self.transport_tick(engine)\n'
                  '                if self.sensor:\n'
                  '                    reading=self.sensor()\n'
                  '                    if reading is not None:engine.sense(*reading)\n'
                  '                for _ in range(100):\n'
                  '                    try:engine.receive(self.incoming.get_nowait())\n'
                  '                    except queue.Empty:break\n'
                  '                for _ in range(100):\n'
                  '                    try:cmd=commands.recv_json(zmq.NOBLOCK)\n'
                  '                    except zmq.Again:break\n'
                  '                    try:\n'
                  "                        if cmd.get('cmd')=='send':engine.enqueue(cmd)\n"
                  "                        elif cmd.get('cmd')=='hello':engine.snapshot()\n"
                  "                        elif cmd.get('cmd')=='threshold':\n"
                  "                            value=float(cmd['db'])\n"
                  "                            if not -140<=value<=20:raise ValueError('Threshold outside -140..20 "
                  "dB')\n"
                  "                            engine.c['cs_threshold_db']=value\n"
                  '                    except Exception as exc:\n'
                  '                        '
                  "emit(dict(event='status',id=cmd.get('id'),status='failed',reason=str(exc)))\n"
                  '                engine.tick();self.stop_event.wait(0.003)\n'
                  '        except Exception as exc:\n'
                  "            self.error=exc;self.ready.set();print('Radio service stopped:',exc,flush=True)\n"
                  '        finally:\n'
                  '            if engine:engine.close()\n'
                  '            commands.close();events.close();context.term()\n'}
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'

      class _EmbeddedRadioLoader(_abc.MetaPathFinder, _abc.Loader):
          def find_spec(self, fullname, path=None, target=None):
              prefix = '_pixel_pulse_radio.'
              if fullname.startswith(prefix) and fullname[len(prefix):] in _RADIO_SOURCES:
                  return _util.spec_from_loader(fullname, self)
              return None

          def create_module(self, spec):
              return None

          def exec_module(self, module):
              name = module.__name__.split('.')[-1]
              module.__file__ = '<Pixel Pulse GRC>/' + name + '.py'
              exec(compile(_RADIO_SOURCES[name], module.__file__, 'exec'), module.__dict__)

      if '_pixel_pulse_radio' not in _sys.modules:
          _package = _types.ModuleType('_pixel_pulse_radio')
          _package.__path__ = []
          _package.__package__ = '_pixel_pulse_radio'
          _sys.modules['_pixel_pulse_radio'] = _package
          _sys.meta_path.insert(0, _EmbeddedRadioLoader())

      from _pixel_pulse_radio.equalizer import TrainingCorrelator
      class blk(TrainingCorrelator):
          def __init__(self, threshold=0.6):
              super().__init__(threshold)
    threshold: radio_config["correlation_threshold"]
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '89.75'
    bandwidth: '1500000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: radio_config["uri"]
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1500000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: radio_config["rx_gain_db"]
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: radio_config["uri"]
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |
      from gnuradio import filter
      import os
      # Pixel Pulse: all project radio modules are embedded below.
      # No sdrchat checkout or separately supplied Python blocks are required.
      import importlib.abc as _abc
      import importlib.util as _util
      import sys as _sys
      import types as _types

      _RADIO_SOURCES = {'config': 'import json\n'
                 'from pathlib import Path\n'
                 '\n'
                 '\n'
                 'def load(path):\n'
                 '    path = Path(path).resolve()\n'
                 '    c = json.loads(path.read_text())\n'
                 "    if not 1 <= c['address'] <= 65534:\n"
                 "        raise ValueError('Node address must be 0x0001..0xFFFE')\n"
                 "    c['state_dir'] = str((path.parent / c['state_dir']).resolve())\n"
                 "    c['config_path'] = str(path)\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n'
                 '\n'
                 '\n'
                 'def addr(value):\n'
                 "    return f'0x{int(value):04X}'\n"
                 '\n'
                 '\n'
                 "_DEFAULT_CONFIG = {'address': 16170, 'name': 'User 1', 'frequency': 2426500000, 'uri': "
                 "'ip:192.168.1.10', 'commands_port': 5555, 'events_port': 5556, 'shared_key': "
                 "'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=', 'state_dir': './data/node_a', 'sample_rate': "
                 "2400000, 'cs_threshold_db': -35.0, 'cs_hysteresis_db': 3.0, 'difs_s': 0.02, 'slot_s': 0.015, "
                 "'ack_timeout_s': 1.0, 'retry_limit': 20, 'cw_min': [8, 16, 32], 'cw_max': 1024, 'aging_s': 30.0, "
                 "'tx_delay_s': 0.02, 'tx_guard_s': 0.01, 'tx_attenuation_db': 0.0, 'rx_gain_db': 45, 'nlms_taps': "
                 "7, 'nlms_mu': 0.2, 'nlms_dd_mu': 0.02, 'nlms_eps': 1e-06, 'correlation_threshold': 0.6, "
                 "'contacts': [], 'local_radio_configured': True}\n"
                 '_original_load = load\n'
                 '\n'
                 'def load(path):\n'
                 '    import os\n'
                 '    path = Path(path)\n'
                 '    if path.exists():\n'
                 '        return _original_load(path)\n'
                 "    if os.environ.get('SDRCHAT_CONFIG') or str(path) != 'configs/node_a.json':\n"
                 "        raise FileNotFoundError('Node configuration does not exist: ' + str(path))\n"
                 '    c = dict(_DEFAULT_CONFIG)\n'
                 "    c['state_dir'] = str(Path(c['state_dir']).resolve())\n"
                 "    Path(c['state_dir']).mkdir(parents=True, exist_ok=True)\n"
                 '    return c\n',
       'engine': '"""Durable, single-flight ARQ with CSMA/CA. Owned by the radio process."""\n'
                 'import hashlib\n'
                 'import json\n'
                 'import random\n'
                 'import sqlite3\n'
                 'import time\n'
                 'import uuid\n'
                 'from collections import deque\n'
                 'from pathlib import Path\n'
                 'from cryptography.fernet import InvalidToken\n'
                 'from .protocol import Codec, TEXT, ACK, BROADCAST, make_fragment, parse_fragment\n'
                 '\n'
                 '\n'
                 'class Engine:\n'
                 '    def __init__(self, config, transmit, event, clock=time.monotonic, rng=None):\n'
                 "        self.c=config; self.me=config['address']; self.transmit=transmit; self.event=event\n"
                 '        self.clock=clock; self.rng=rng or random.SystemRandom(); '
                 "self.codec=Codec(config['shared_key'])\n"
                 "        self.db=sqlite3.connect(str(Path(config['state_dir'])/'radio.sqlite'))\n"
                 "        self.db.execute('PRAGMA journal_mode=WAL'); self.db.execute('PRAGMA synchronous=FULL')\n"
                 "        self.db.executescript('''\n"
                 '        CREATE TABLE IF NOT EXISTS jobs(id TEXT PRIMARY KEY,dst INTEGER,priority INTEGER,kind '
                 'TEXT,name TEXT,data BLOB,created REAL,status TEXT,part INTEGER DEFAULT 0);\n'
                 '        CREATE TABLE IF NOT EXISTS fragments(src INTEGER,id TEXT,part INTEGER,total INTEGER,meta '
                 'TEXT,data BLOB,PRIMARY KEY(src,id,part));\n'
                 '        CREATE TABLE IF NOT EXISTS receipts(src INTEGER,seq INTEGER,digest TEXT,PRIMARY '
                 'KEY(src,seq));\n'
                 '        CREATE TABLE IF NOT EXISTS received(src INTEGER,id TEXT,kind TEXT,name TEXT,data '
                 'BLOB,PRIMARY KEY(src,id));\n'
                 '        CREATE TABLE IF NOT EXISTS settings(key TEXT PRIMARY KEY,value INTEGER);\n'
                 "        ''')\n"
                 '        self.db.execute("INSERT OR IGNORE INTO settings '
                 'VALUES(\'sequence\',?)",(self.rng.randrange(1,2**30),))\n'
                 '        self.db.execute("UPDATE jobs SET status=\'queued\' WHERE status IN '
                 '(\'sending\',\'sent\')")\n'
                 '        self.db.commit()\n'
                 '        self.queues=[deque(),deque(),deque()]\n'
                 '        self.jobs={}; self.current=None; self.flight=None; self.acks=deque(); '
                 'self.ack_keys=set()\n'
                 '        self.contender=None; self.idle_since=None; self.tx_until=0; self.busy=True\n'
                 '        self.power=-200.; self.sense_at=-1e9; self.last_status=-1e9\n'
                 '        for row in self.db.execute("SELECT id,dst,priority,kind,name,data,created,part FROM jobs '
                 'WHERE status=\'queued\' ORDER BY created,rowid"):\n'
                 "            j=dict(zip(('id','dst','priority','kind','name','data','created','part'),row))\n"
                 "            j['enqueued']=self.clock()-max(0,time.time()-j['created']); self.jobs[j['id']]=j\n"
                 "            self.queues[j['priority']].append(j)\n"
                 '\n'
                 '    def close(self):\n'
                 '        self.db.close()\n'
                 '\n'
                 '    def status(self, ident, state, **extra):\n'
                 "        self.db.execute('UPDATE jobs SET status=? WHERE id=?',(state,ident)); self.db.commit()\n"
                 "        self.event(dict(event='status',id=ident,status='sent' if state=='broadcast_sent' else "
                 'state,**extra))\n'
                 '\n'
                 '    def enqueue(self, command):\n'
                 "        ident=str(uuid.UUID(command['id']))\n"
                 "        found=self.db.execute('SELECT status FROM jobs WHERE id=?',(ident,)).fetchone()\n"
                 '        if found:\n'
                 "            self.event(dict(event='status',id=ident,status='sent' if found[0]=='broadcast_sent' "
                 'else found[0])); return\n'
                 "        dst=int(command['dst']); pri=int(command['priority']); kind=command['kind']\n"
                 '        if dst==self.me or not 1<=dst<=BROADCAST or pri not in (0,1,2):\n'
                 "            raise ValueError('Invalid destination or priority')\n"
                 "        if kind=='text':\n"
                 "            data=command['text'].encode('utf-8'); name='message.txt'\n"
                 "            if not 0<len(data)<=65536: raise ValueError('Text must contain 1..65536 UTF-8 "
                 "bytes')\n"
                 "        elif kind in ('image','audio','file'):\n"
                 "            p=Path(command['path']).resolve()\n"
                 '            if not p.is_file() or not 0<p.stat().st_size<=16*1024*1024:\n'
                 "                raise ValueError('Choose a nonempty file up to 16 MiB')\n"
                 "            data=p.read_bytes(); name=str(command.get('name',p.name))[:120]\n"
                 "        else: raise ValueError('Unknown message type')\n"
                 '        j=dict(id=ident,dst=dst,priority=pri,kind=kind,name=name,data=data,\n'
                 '               created=time.time(),part=0,enqueued=self.clock())\n'
                 "        self.db.execute('INSERT INTO jobs VALUES(?,?,?,?,?,?,?,?,?)',\n"
                 "            (ident,dst,pri,kind,name,data,j['created'],'queued',0)); self.db.commit()\n"
                 '        self.jobs[ident]=j; self.queues[pri].append(j)\n'
                 "        self.status(ident,'queued')\n"
                 '\n'
                 '    def snapshot(self):\n'
                 "        for ident,status in self.db.execute('SELECT id,status FROM jobs'):\n"
                 "            self.event(dict(event='status',id=ident,status='sent' if status=='broadcast_sent' "
                 'else status))\n'
                 "        for src,ident,kind,name,data in self.db.execute('SELECT src,id,kind,name,data FROM "
                 "received'):\n"
                 '            self.deliver_event(src,ident,kind,name,data)\n'
                 '\n'
                 '    def deliver_event(self, src, ident, kind, name, data):\n'
                 "        info=dict(event='received',id=ident,src=src,kind=kind,name=name)\n"
                 "        if kind=='text': info['text']=data.decode('utf-8')\n"
                 '        else:\n'
                 "            directory=Path(self.c['state_dir'])/'received'; directory.mkdir(exist_ok=True)\n"
                 "            safe=''.join(c if c.isalnum() or c in '.-_ ' else '_' for c in "
                 'Path(name).name)[:120]\n'
                 "            path=directory/(str(src)+'_'+ident+'_'+safe)\n"
                 '            if not path.exists():\n'
                 '                '
                 "temp=path.with_suffix(path.suffix+'.part');temp.write_bytes(data);temp.replace(path)\n"
                 "            info['path']=str(path)\n"
                 '        self.event(info)\n'
                 '\n'
                 '    def sense(self, power_db, busy=None):\n'
                 '        self.power=float(power_db); self.sense_at=self.clock()\n'
                 '        if busy is None:\n'
                 "            limit=self.c['cs_threshold_db']-(self.c['cs_hysteresis_db'] if self.busy else 0)\n"
                 '            self.busy=self.power>limit\n'
                 '        else:self.busy=bool(busy)\n'
                 '        if self.busy:\n'
                 '            self.idle_since=None\n'
                 "            if self.contender:self.contender.pop('slot_at',None)\n"
                 '\n'
                 '    def receive(self, wire):\n'
                 '        try:\n'
                 '            f=self.codec.unpack(wire,self.me)\n'
                 "            if f['typ']==ACK:\n"
                 '                p=self.flight\n'
                 "                if p and p.get('sent_once') and f['dst']==self.me and f['src']==p['dst'] and "
                 "f['seq']==p['seq'] and f['body']==uuid.UUID(self.current['id']).bytes:\n"
                 '                    self.complete_packet()\n'
                 '                return\n'
                 '            digest=hashlib.sha256(wire).hexdigest()\n'
                 "            receipt=self.db.execute('SELECT digest FROM receipts WHERE src=? AND "
                 "seq=?',(f['src'],f['seq'])).fetchone()\n"
                 "            ident,index,count,meta,data=parse_fragment(f['body'])\n"
                 '            if receipt and receipt[0]!=digest: return\n'
                 '            if not receipt:\n'
                 '                # Completed messages may be retransmitted with a new sequence after a restart.\n'
                 "                done=self.db.execute('SELECT 1 FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 '                if not done:\n'
                 '                    m=json.dumps(meta,sort_keys=True)\n'
                 "                    existing=self.db.execute('SELECT meta,data FROM fragments WHERE src=? AND "
                 "id=? AND part=?',(f['src'],ident,index)).fetchone()\n"
                 "                    if existing and existing!=(m,data):raise ValueError('Conflicting fragment')\n"
                 "                    other=self.db.execute('SELECT meta FROM fragments WHERE src=? AND id=? LIMIT "
                 "1',(f['src'],ident)).fetchone()\n"
                 "                    if other and other[0]!=m:raise ValueError('Conflicting metadata')\n"
                 "                    self.db.execute('INSERT OR IGNORE INTO fragments "
                 "VALUES(?,?,?,?,?,?)',(f['src'],ident,index,count,m,data))\n"
                 "                    rows=self.db.execute('SELECT data FROM fragments WHERE src=? AND id=? ORDER "
                 "BY part',(f['src'],ident)).fetchall()\n"
                 '                    if len(rows)==count:\n'
                 "                        full=b''.join(r[0] for r in rows)\n"
                 "                        if len(full)!=meta['size'] or "
                 "hashlib.sha256(full).hexdigest()!=meta['sha256']:\n"
                 "                            raise ValueError('Whole-message SHA-256 failure')\n"
                 "                        if meta['kind']=='text':full.decode('utf-8')\n"
                 "                        self.db.execute('INSERT INTO received "
                 "VALUES(?,?,?,?,?)',(f['src'],ident,meta['kind'],meta['name'],full))\n"
                 "                        self.db.execute('DELETE FROM fragments WHERE src=? AND "
                 "id=?',(f['src'],ident))\n"
                 "                self.db.execute('INSERT INTO receipts "
                 "VALUES(?,?,?)',(f['src'],f['seq'],digest)); self.db.commit()\n"
                 '                # Reconstruct delivery event from durable storage, before acknowledging '
                 'completion.\n'
                 "                received=self.db.execute('SELECT kind,name,data FROM received WHERE src=? AND "
                 "id=?',(f['src'],ident)).fetchone()\n"
                 "                if received:self.deliver_event(f['src'],ident,*received)\n"
                 "            if f['dst']!=BROADCAST and (f['src'],f['seq']) not in self.ack_keys:\n"
                 "                self.ack_keys.add((f['src'],f['seq']))\n"
                 "                raw=self.codec.pack(f['src'],self.me,f['seq'],0,ACK,uuid.UUID(ident).bytes)\n"
                 '                '
                 "self.acks.append(dict(wire=raw,ack=True,dst=f['src'],seq=f['seq'],cw=4,slots=None))\n"
                 '        except (ValueError,KeyError,TypeError,InvalidToken,UnicodeError) as exc:\n'
                 '            self.db.rollback()\n'
                 "            self.event(dict(event='diagnostic',message='RX rejected: '+str(exc)))\n"
                 '\n'
                 '    def choose(self):\n'
                 '        now=self.clock()\n'
                 "        heads=[(max(0,p-int((now-q[0]['enqueued'])/self.c['aging_s'])),q[0]['created'],p) for "
                 'p,q in enumerate(self.queues) if q]\n'
                 '        if not heads:return None\n'
                 '        _,_,p=min(heads)\n'
                 '        return self.queues[p].popleft()\n'
                 '\n'
                 '    def new_packet(self):\n'
                 '        j=self.current\n'
                 '        seq=self.db.execute("SELECT value FROM settings WHERE key=\'sequence\'").fetchone()[0]\n'
                 "        if seq>=0xFFFFFFFF:raise RuntimeError('Sequence space exhausted; provision a new node "
                 "address')\n"
                 '        self.db.execute("UPDATE settings SET value=? WHERE '
                 'key=\'sequence\'",(seq+1,));self.db.commit()\n'
                 "        body,count=make_fragment(j,j['part'])\n"
                 "        self.flight=dict(wire=self.codec.pack(j['dst'],self.me,seq,j['priority'],TEXT,body),\n"
                 '                         '
                 "dst=j['dst'],seq=seq,retries=0,cw=self.c['cw_min'][j['priority']],slots=None,\n"
                 '                         deadline=None,ack=False,count=count)\n'
                 '\n'
                 '    def complete_packet(self):\n'
                 '        j=self.current;p=self.flight\n'
                 '        if self.contender is p:self.contender=None\n'
                 "        j['part']+=1\n"
                 "        self.db.execute('UPDATE jobs SET part=? WHERE "
                 "id=?',(j['part'],j['id']));self.db.commit()\n"
                 '        self.flight=None\n'
                 "        if j['part']>=p['count']:\n"
                 "            self.status(j['id'],'broadcast_sent' if j['dst']==BROADCAST else "
                 "'delivered',broadcast=j['dst']==BROADCAST)\n"
                 "            self.jobs.pop(j['id'],None);self.current=None\n"
                 '        else:\n'
                 "            self.status(j['id'],'sending',progress=j['part']/p['count'])\n"
                 "            self.queues[j['priority']].appendleft(j);self.current=None\n"
                 '\n'
                 '    def tick(self):\n'
                 '        now=self.clock()\n'
                 '        if now-self.last_status>=0.5:\n'
                 "            self.event(dict(event='telemetry',power_db=self.power,busy=self.busy,\n"
                 '                            waiting=sum(map(len,self.queues)),active=bool(self.current),\n'
                 '                            queues=[len(q) for q in self.queues],address=self.me))\n'
                 '            self.last_status=now\n'
                 '        if now<self.tx_until:\n'
                 '            self.idle_since=None;return\n'
                 "        if self.flight and self.flight.get('broadcast_done'):\n"
                 '            self.complete_packet()\n'
                 "        if self.flight and self.flight['deadline'] is not None and "
                 "now>=self.flight['deadline']:\n"
                 '            p=self.flight\n'
                 "            if p['retries']>=self.c['retry_limit']:\n"
                 "                self.status(self.current['id'],'failed',reason='ACK timeout: retry limit "
                 "reached')\n"
                 "                self.jobs.pop(self.current['id'],None);self.current=None;self.flight=None\n"
                 '                if self.contender is p:self.contender=None\n'
                 '            else:\n'
                 "                p['retries']+=1;p['cw']=min(self.c['cw_max'],p['cw']*2)\n"
                 "                p['deadline']=None;p['slots']=None\n"
                 "                self.status(self.current['id'],'sending',retry=p['retries'])\n"
                 '        if self.current is None:\n'
                 '            self.current=self.choose()\n'
                 '        if self.current and self.flight is None:self.new_packet()\n'
                 '        # ACKs have a separate control queue. They never wait behind a data ACK timeout.\n'
                 '        if self.acks:\n'
                 '            candidate=self.acks[0]\n'
                 "        elif self.flight and self.flight['deadline'] is None:\n"
                 '            candidate=self.flight\n'
                 '        else:\n'
                 '            self.contender=None;return\n'
                 '        if candidate is not self.contender:\n'
                 "            self.contender=candidate; self.idle_since=None;candidate.pop('slot_at',None)\n"
                 '        if self.busy or now-self.sense_at>0.2:\n'
                 "            self.idle_since=None;candidate.pop('slot_at',None);return\n"
                 '        if self.idle_since is None:self.idle_since=now\n'
                 "        if now-self.idle_since<self.c['difs_s']:return\n"
                 "        if candidate['slots'] is None:\n"
                 "            candidate['slots']=self.rng.randrange(candidate['cw']);candidate['slot_at']=now\n"
                 "        elif 'slot_at' not in candidate:candidate['slot_at']=now\n"
                 "        slots=int((now-candidate['slot_at'])/self.c['slot_s'])\n"
                 "        candidate['slots']=max(0,candidate['slots']-slots)\n"
                 "        candidate['slot_at']+=slots*self.c['slot_s']\n"
                 "        if candidate['slots']:return\n"
                 "        if not candidate['ack']:self.status(self.current['id'],'sending')\n"
                 "        try:duration=float(self.transmit(candidate['wire']))\n"
                 '        except Exception as exc:\n'
                 "            self.event(dict(event='diagnostic',message='TX unavailable: '+str(exc)))\n"
                 "            candidate['slots']=None;self.idle_since=None;return\n"
                 '        self.tx_until=now+duration;self.idle_since=None;self.contender=None\n'
                 "        if candidate['ack']:\n"
                 "            self.acks.popleft();self.ack_keys.discard((candidate['dst'],candidate['seq']))\n"
                 '        else:\n'
                 "            candidate['sent_once']=True\n"
                 "            candidate['deadline']=self.tx_until+self.c['ack_timeout_s']\n"
                 "            if candidate['dst']==BROADCAST:candidate['broadcast_done']=True\n"
                 "            self.status(self.current['id'],'sent',retry=candidate['retries'])\n",
       'equalizer': 'import ctypes\n'
                    'import hashlib\n'
                    'from pathlib import Path\n'
                    'import numpy as np\n'
                    'import pmt\n'
                    'from gnuradio import gr\n'
                    '\n'
                    '\n'
                    'def training_bytes(length=2048):\n'
                    "    return b''.join(hashlib.sha256(b'QPSK-training-v1'+i.to_bytes(4,'big')).digest()\n"
                    '                    for i in range((length+31)//32))[:length]\n'
                    '\n'
                    '\n'
                    'def training_symbols():\n'
                    '    # Last 64 bytes of the EXISTING deterministic prefix. Constant differential\n'
                    '    # phase before this segment is absorbed by training; no change to TX bytes.\n'
                    '    bits=np.unpackbits(np.frombuffer(training_bytes()[-64:],dtype=np.uint8)).reshape(-1,2)\n'
                    '    chunks=bits[:,0]*2+bits[:,1]\n'
                    '    mapped=np.array([0,1,3,2])[chunks]\n'
                    '    index=np.cumsum(mapped)%4\n'
                    '    return np.array([.707+.707j,-.707+.707j,-.707-.707j,.707-.707j],np.complex64)[index]\n'
                    '\n'
                    '\n'
                    'class TrainingCorrelator(gr.sync_block):\n'
                    '    def __init__(self, threshold=.6):\n'
                    "        gr.sync_block.__init__(self,name='QPSK training "
                    "correlator',in_sig=[np.complex64],out_sig=[np.complex64])\n"
                    '        symbols=training_symbols()[:64]\n'
                    '        t=np.arange(-8,9)/2.;a=.35\n'
                    '        pulse=np.sinc(t)*np.cos(np.pi*a*t)/(1-(2*a*t)**2)\n'
                    '        '
                    'self.ref=np.convolve(np.kron(symbols,[1,0]),pulse)[8:8+2*len(symbols)-1].astype(np.complex64)\n'
                    '        self.energy=float(np.vdot(self.ref,self.ref).real);self.threshold=threshold\n'
                    '        self.delay=(len(self.ref)+9)//2*2\n'
                    '        self.set_history(self.delay+1);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '        self.next_position=0;self.last_position=-10000;self.count=0\n'
                    '\n'
                    '    def work(self, inputs, outputs):\n'
                    '        x=inputs[0];out=outputs[0];n=len(out);out[:]=x[:n]\n'
                    '        base=self.nitems_written(0)-self.delay\n'
                    "        c=np.correlate(x,self.ref,'valid')\n"
                    "        power=np.convolve(np.abs(x).astype(np.float64)**2,np.ones(len(self.ref)),'valid')\n"
                    '        score=np.abs(c)**2/(self.energy*power+1e-12)\n'
                    '        '
                    'lo=max(self.next_position-base,2,-base);hi=min(len(score)-3,n+self.delay-len(self.ref))\n'
                    '        for j in np.flatnonzero(score[lo:hi+1]>self.threshold)+lo:\n'
                    '            if score[j]<max(score[j-2:j]) or score[j]<=max(score[j+1:j+3]):continue\n'
                    '            absolute=base+int(j)\n'
                    '            if absolute-self.last_position<512:continue\n'
                    '            offset=absolute+self.delay\n'
                    '            if offset<self.nitems_written(0):continue\n'
                    '            '
                    "self.add_item_tag(0,offset,pmt.intern('corr_est'),pmt.from_double(float(score[j])))\n"
                    '            self.last_position=absolute;self.count+=1\n'
                    '        if hi>=lo:self.next_position=base+hi+1\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    'class NLMS(gr.decim_block):\n'
                    '    def __init__(self,taps=7,mu=.2,dd_mu=.02,eps=1e-6):\n'
                    "        gr.decim_block.__init__(self,name='Regularized QPSK "
                    "NLMS',in_sig=[np.complex64],out_sig=[np.complex64],decim=2)\n"
                    '        if taps<3 or taps%2!=1 or not 0<mu<2 or not 0<dd_mu<2 or eps<=0:raise '
                    "ValueError('Invalid NLMS parameters')\n"
                    '        self.taps=taps;self.mu=mu;self.dd_mu=dd_mu;self.eps=eps\n'
                    '        self.weights=np.zeros(taps,np.complex64);self.weights[0]=1\n'
                    '        '
                    'self.training=training_symbols();self.pos=ctypes.c_int(0);self.active=ctypes.c_int(0)\n'
                    '        lib=_embedded_native_library()\n'
                    "        if not lib.exists():raise RuntimeError('Run ./setup.sh to build the NLMS kernel')\n"
                    '        self.lib=ctypes.CDLL(str(lib));self.fn=self.lib.nlms_process\n'
                    '        '
                    'self.fn.argtypes=[ctypes.c_void_p,ctypes.c_void_p,ctypes.c_int,ctypes.c_int,ctypes.c_void_p,\n'
                    '            '
                    'ctypes.c_void_p,ctypes.c_int,ctypes.POINTER(ctypes.c_int),ctypes.POINTER(ctypes.c_int),\n'
                    '            '
                    'ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_float,ctypes.c_void_p,ctypes.c_int]\n'
                    '        '
                    'self.fn.restype=None;self.set_history(taps);self.set_tag_propagation_policy(gr.TPP_DONT)\n'
                    '\n'
                    '    def work(self,inputs,outputs):\n'
                    '        x=inputs[0];y=outputs[0];n=len(y)\n'
                    "        tags=self.get_tags_in_window(0,0,2*n,pmt.intern('corr_est'))\n"
                    '        starts=np.array([int(t.offset-self.nitems_read(0)) for t in tags],np.int32)\n'
                    '        self.fn(x.ctypes.data,y.ctypes.data,n,self.taps,self.weights.ctypes.data,\n'
                    '                '
                    'self.training.ctypes.data,len(self.training),ctypes.byref(self.pos),ctypes.byref(self.active),\n'
                    '                self.mu,self.dd_mu,self.eps,1e-8,starts.ctypes.data,len(starts))\n'
                    '        return n\n'
                    '\n'
                    '\n'
                    "_NATIVE_SOURCE = '// Batched regularized complex NLMS. y = w^H x, e = d-y.\\n#include "
                    '<complex>\\n#include <cmath>\\n#include <algorithm>\\nusing C = std::complex<float>;\\nextern '
                    '"C" void nlms_process(const C* input, C* output, int n, int '
                    'taps,\\n                              C* weights, const C* training, int '
                    'training_len,\\n                              int* training_pos, int* active, float '
                    'mu,\\n                              float dd_mu, float eps, float '
                    'gate,\\n                              const int* starts, int nstarts) {\\n    int '
                    'tag=0;\\n    for(int i=0;i<n;i++) {\\n        if(tag<nstarts && starts[tag]<=2*i+1) '
                    '{\\n            *training_pos=0;*active=1;tag++;\\n            '
                    'std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);\\n        }\\n        const C* '
                    'newest=input+taps-1+2*i;\\n        C y(0,0);float power=0;\\n        for(int k=0;k<taps;k++) '
                    '{y+=std::conj(weights[k])*newest[-k];power+=std::norm(newest[-k]);}\\n        '
                    'output[i]=y;\\n        if(!*active || power<gate || !std::isfinite(power))continue;\\n        '
                    'bool train=*training_pos<training_len;\\n        C '
                    'desired=train?training[(*training_pos)++]:C(y.real()>=0?.707f:-.707f,y.imag()>=0?.707f:-.707f);\\n        '
                    'C error=desired-y;\\n        float step=(train?mu:dd_mu)/(eps+power);\\n        for(int '
                    'k=0;k<taps;k++)weights[k]+=step*std::conj(error)*newest[-k];\\n        // Disable adaptation '
                    'on catastrophic divergence; reacquire on next preamble.\\n        '
                    'if(!std::isfinite(std::norm(y)) || std::norm(y)>1e6f) '
                    "{*active=0;std::fill(weights,weights+taps,C(0,0));weights[0]=C(1,0);}\\n    }\\n}\\n'\n"
                    '_native_directory = None\n'
                    '\n'
                    'def _embedded_native_library():\n'
                    '    global _native_directory\n'
                    '    import shutil\n'
                    '    import subprocess\n'
                    '    import tempfile\n'
                    '    if _native_directory is None:\n'
                    "        compiler = shutil.which('g++')\n"
                    '        if compiler is None:\n'
                    "            raise RuntimeError('The embedded NLMS source needs g++. Install g++ and run "
                    "again.')\n"
                    "        directory = tempfile.TemporaryDirectory(prefix='pixel-pulse-nlms-')\n"
                    '        folder = Path(directory.name)\n'
                    "        source = folder / 'nlms.cpp'\n"
                    '        source.write_text(_NATIVE_SOURCE)\n'
                    '        try:\n'
                    "            subprocess.run([compiler, '-O3', '-std=c++17', '-shared', '-fPIC', str(source), "
                    "'-o', str(folder / 'libnlms.so')], check=True, capture_output=True, text=True)\n"
                    '        except subprocess.CalledProcessError as exc:\n'
                    '            directory.cleanup()\n'
                    "            raise RuntimeError('Could not compile embedded NLMS source: ' + exc.stderr) from "
                    'exc\n'
                    '        _native_directory = directory\n'
                    "    return Path(_native_directory.name) / 'libnlms.so'\n",
       'protocol': '"""Network-order routing header + authenticated encrypted fragment or ACK.\n'
                   '\n'
                   'The GNU Radio graph adds CRC32 and RS outside this layer. The simulator uses\n'
                   'the same CRC and RS codec. Routing fields are repeated inside Fernet so they\n'
                   'cannot be altered without authentication failure.\n'
                   '"""\n'
                   'import hashlib\n'
                   'import json\n'
                   'import struct\n'
                   'import uuid\n'
                   'import zlib\n'
                   'from cryptography.fernet import Fernet\n'
                   'from .reedsolo_bundled import RSCodec\n'
                   '\n'
                   'TEXT, ACK = 1, 2\n'
                   'BROADCAST = 0xFFFF\n'
                   "HEADER = struct.Struct('!HHIBBH')\n"
                   "ROUTE = struct.Struct('!HHIBB')\n"
                   "FRAGMENT = struct.Struct('!16sHHH')\n"
                   '\n'
                   '\n'
                   'class Codec:\n'
                   '    def __init__(self, key):\n'
                   '        self.cipher = Fernet(key.encode() if isinstance(key, str) else key)\n'
                   '        self.rs = RSCodec(16, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8)\n'
                   '\n'
                   '    def pack(self, dst, src, seq, priority, typ, body):\n'
                   '        if not 1 <= src < BROADCAST or not 1 <= dst <= BROADCAST:\n'
                   "            raise ValueError('Invalid address')\n"
                   '        if priority not in (0, 1, 2) or typ not in (TEXT, ACK):\n'
                   "            raise ValueError('Invalid priority or packet type')\n"
                   '        route = ROUTE.pack(dst, src, seq, priority, typ)\n'
                   '        token = self.cipher.encrypt(route + body)\n'
                   '        wire = HEADER.pack(dst, src, seq, priority, typ, len(token)) + token\n'
                   '        if len(wire) > 4092:\n'
                   "            raise ValueError('Frame exceeds original 4092-byte budget')\n"
                   '        return wire\n'
                   '\n'
                   '    def unpack(self, wire, me):\n'
                   '        if len(wire) < HEADER.size or len(wire) > 4092:\n'
                   "            raise ValueError('Invalid frame size')\n"
                   '        dst, src, seq, pri, typ, length = HEADER.unpack_from(wire)\n'
                   '        if dst not in (me, BROADCAST) or src == me or not 1 <= src < BROADCAST:\n'
                   "            raise ValueError('Frame for another node or own echo')\n"
                   '        if length != len(wire)-HEADER.size or pri not in (0,1,2) or typ not in (TEXT,ACK):\n'
                   "            raise ValueError('Malformed header')\n"
                   '        raw = self.cipher.decrypt(wire[HEADER.size:])\n'
                   '        if raw[:ROUTE.size] != ROUTE.pack(dst,src,seq,pri,typ):\n'
                   "            raise ValueError('Authenticated routing mismatch')\n"
                   '        return dict(dst=dst, src=src, seq=seq, priority=pri, typ=typ, body=raw[ROUTE.size:])\n'
                   '\n'
                   '    def protect(self, raw):\n'
                   "        data = raw + struct.pack('!I', zlib.crc32(raw))\n"
                   '        return bytes(self.rs.encode(data))\n'
                   '\n'
                   '    def recover(self, coded):\n'
                   '        data = bytes(self.rs.decode(coded)[0])\n'
                   "        if len(data)<4 or zlib.crc32(data[:-4]) != struct.unpack('!I',data[-4:])[0]:\n"
                   "            raise ValueError('CRC failure')\n"
                   '        return data[:-4]\n'
                   '\n'
                   '\n'
                   'def make_fragment(job, index):\n'
                   "    data = job['data']\n"
                   "    chunk = 128 if job['kind']=='text' else 1024\n"
                   '    count = max(1, (len(data)+chunk-1)//chunk)\n'
                   "    meta = json.dumps(dict(kind=job['kind'], name=job['name'], size=len(data),\n"
                   '                           '
                   "sha256=hashlib.sha256(data).hexdigest()),separators=(',',':')).encode()\n"
                   '    return '
                   "FRAGMENT.pack(uuid.UUID(job['id']).bytes,index,count,len(meta))+meta+data[index*chunk:(index+1)*chunk], "
                   'count\n'
                   '\n'
                   '\n'
                   'def parse_fragment(body):\n'
                   '    if len(body)<FRAGMENT.size:\n'
                   "        raise ValueError('Truncated fragment')\n"
                   '    ident,index,count,mlen = FRAGMENT.unpack_from(body)\n'
                   '    if not 1<=count<=16384 or index>=count or not 0<mlen<=1024:\n'
                   "        raise ValueError('Invalid fragmentation')\n"
                   '    meta = json.loads(body[FRAGMENT.size:FRAGMENT.size+mlen])\n'
                   "    if meta['kind'] not in ('text','image','audio','file') or not "
                   "0<meta['size']<=16*1024*1024:\n"
                   "        raise ValueError('Invalid transfer metadata')\n"
                   "    chunk = 128 if meta['kind']=='text' else 1024\n"
                   "    if meta['kind']=='text' and meta['size']>65536:\n"
                   "        raise ValueError('Text exceeds original 64 KiB limit')\n"
                   "    if count != (meta['size']+chunk-1)//chunk:\n"
                   "        raise ValueError('Wrong fragment count')\n"
                   '    data=body[FRAGMENT.size+mlen:]\n'
                   "    if len(data)!=min(chunk,meta['size']-index*chunk):\n"
                   "        raise ValueError('Wrong fragment length')\n"
                   '    return str(uuid.UUID(bytes=ident)),index,count,meta,data\n',
       'radio_blocks': 'import os\n'
                       'import queue\n'
                       'import threading\n'
                       'import time\n'
                       'import numpy as np\n'
                       'import pmt\n'
                       'from gnuradio import gr\n'
                       'from .config import load\n'
                       'from .service import Service\n'
                       '\n'
                       '\n'
                       'def airtime(c, raw_length):\n'
                       '    """Estimate a framed RF burst including host delay and turnaround guard."""\n'
                       '    coded=raw_length+4+16*((raw_length+4+238)//239)\n'
                       "    return (2048+12+coded+2570)*16/c['sample_rate']+c['tx_delay_s']+c['tx_guard_s']\n"
                       '\n'
                       '\n'
                       'class MacBridge(gr.sync_block):\n'
                       '    """Raw RX energy observer + PDU socket/MAC service. No stream output."""\n'
                       "    def __init__(self,config_path='configs/node_a.json'):\n"
                       "        gr.sync_block.__init__(self,name='CSMA/CA + app "
                       "bridge',in_sig=[np.complex64],out_sig=None)\n"
                       '        self.c=load(config_path);self.incoming=queue.Queue(maxsize=4096)\n'
                       '        '
                       'self.reading=None;self.read_at=0;self.lock=threading.Lock();self.tx_lock=threading.Lock()\n'
                       '        self.tx_at=0;self.tx_end=0;self.sink=None;self.source=None;self.muted=True\n'
                       '        '
                       "self.message_port_register_in(pmt.intern('rx_in'));self.set_msg_handler(pmt.intern('rx_in'),self.receive)\n"
                       "        self.message_port_register_out(pmt.intern('tx_out'))\n"
                       '        self.service=Service(self.c,self.send,self.incoming,self.sensor)\n'
                       '\n'
                       '    def attach_radio(self,sink,source):\n'
                       '        self.sink=sink;self.source=source\n'
                       '\n'
                       '    def start(self):\n'
                       "        if self.sink is None:raise RuntimeError('Launch with python3 -m sdrchat.hardware; "
                       "radio mute hook is required')\n"
                       '        self.sink.set_attenuation(0,89.75)\n'
                       '        self.service.start();return True\n'
                       '\n'
                       '    def stop(self):\n'
                       '        self.service.stop()\n'
                       '        if self.sink:self.sink.set_attenuation(0,89.75)\n'
                       '        return True\n'
                       '\n'
                       '    def sensor(self):\n'
                       '        now=time.monotonic()\n'
                       '        if not self.muted and now>=self.tx_end:\n'
                       '            self.sink.set_attenuation(0,89.75);self.muted=True\n'
                       '        with self.lock:\n'
                       '            if now-self.read_at>.1:return None\n'
                       '            return self.reading,None\n'
                       '\n'
                       '    def send(self,wire):\n'
                       "        if self.sink is None:raise RuntimeError('Radio sink not attached')\n"
                       "        self.sink.set_attenuation(0,self.c['tx_attenuation_db']);self.muted=False\n"
                       '        duration=airtime(self.c,len(wire))\n'
                       '        self.tx_at=time.monotonic();self.tx_end=self.tx_at+duration\n'
                       '        '
                       "self.message_port_pub(pmt.intern('tx_out'),pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(wire),list(wire))))\n"
                       '        return duration\n'
                       '\n'
                       '    def receive(self,msg):\n'
                       '        # Ignore own RF echo during the estimated transmission/turnaround window.\n'
                       '        if time.monotonic()<self.tx_end:return\n'
                       '        if pmt.is_pair(msg) and pmt.is_u8vector(pmt.cdr(msg)):\n'
                       '            try:self.incoming.put_nowait(bytes(pmt.u8vector_elements(pmt.cdr(msg))))\n'
                       '            except queue.Full:pass\n'
                       '\n'
                       '    def work(self,inputs,outputs):\n'
                       '        x=inputs[0]\n'
                       '        if len(x):\n'
                       '            power=10*np.log10(max(float(np.mean(np.abs(x)**2)),1e-20))\n'
                       '            with self.lock:self.reading=power;self.read_at=time.monotonic()\n'
                       '        return len(x)\n',
       'reedsolo_bundled': '#!/usr/bin/env python\n'
                           '# -*- coding: utf-8 -*-\n'
                           '\n'
                           '# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n'
                           '# Copyright (c) 2015 rotorgit\n'
                           '# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n'
                           '\n'
                           "'''\n"
                           'Reed Solomon\n'
                           '============\n'
                           '\n'
                           'A pure-python `universal errors-and-erasures Reed-Solomon Codec '
                           '<http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n'
                           ', based on the wonderful tutorial at\n'
                           '`wikiversity '
                           '<http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\n'
                           'written by "Bobmath" and "LRQ3000".\n'
                           '\n'
                           'The code of wikiversity is here consolidated into a nice API with exceptions '
                           'handling.\n'
                           'The algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\n'
                           'v the number of erasures and nsym = n-k = the number of ECC (error correction code) '
                           'symbols.\n'
                           'This means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n'
                           '(errors where you know the position), and a combination of both errors and erasures.\n'
                           'The code should work on pretty much any reasonable version of python (2.4-3.5),\n'
                           "but I'm only testing on 2.7 - 3.4.\n"
                           '\n'
                           '.. note::\n'
                           '   The codec is universal, meaning that it can decode any message encoded by another '
                           'RS encoder\n'
                           '   as long as you provide the correct parameters.\n'
                           '   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will '
                           'be slower, first because\n'
                           "   we cannot then use the optimized bytearray() structure but only array.array('i', "
                           '...), and also because\n'
                           "   Reed-Solomon's complexity is quadratic (both in encoding and decoding), so this "
                           'means that the longer\n'
                           '   your messages, the longer it will take to encode/decode (quadratically!).\n'
                           '\n'
                           '   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the '
                           'ECC symbols,\n'
                           '   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message '
                           'length and the maximum\n'
                           '   value for one character is constrained by the same mathematical reason). By '
                           'default, we use the field GF(2^8),\n'
                           '   which means that you are limited to values between 0 and 255 (perfect to represent '
                           'a single hexadecimal\n'
                           '   symbol on computers, so you can encode any binary stream) and limited to '
                           'messages+ecc of maximum\n'
                           '   length 255. However, you can "chunk" longer messages to fit them into the message '
                           'length limit.\n'
                           '   The ``RSCodec`` class will automatically apply chunking, by splitting longer '
                           'messages into chunks and\n'
                           "   encode/decode them separately; it shouldn't make a difference from an API "
                           'perspective (ie, from your POV).\n'
                           '\n'
                           '::\n'
                           '\n'
                           '    # Initialization\n'
                           '    >>> from reedsolo import RSCodec\n'
                           '    >>> rsc = RSCodec(10)  # 10 ecc symbols\n'
                           '\n'
                           '    # Encoding\n'
                           '    >>> rsc.encode([1,2,3,4])\n'
                           "    b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M'\n"
                           '    >>> rsc.encode(bytearray([1,2,3,4]))\n'
                           "    bytearray(b'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M')\n"
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa'\n"
                           '    # Note that chunking is supported transparently to encode any string length.\n'
                           '\n'
                           '    # Decoding (repairing)\n'
                           "    >>> rsc.decode(b'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa')[0]\n"
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 3 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa')[0]     # 5 "
                           'errors\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa')[0]        # 6 "
                           'errors - fail\n'
                           '    Traceback (most recent call last):\n'
                           '      ...\n'
                           '    ReedSolomonError: Could not locate error\n'
                           '\n'
                           '    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 '
                           'erasures)\n'
                           "    >>> rsc.encode(b'hello world')\n"
                           "    b'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2='\n"
                           "    >>> rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')[0]         # 6 "
                           'errors - ok\n'
                           "    b'hello world'\n"
                           "    >>> rsc.decode(b'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=', erase_pos=[3, 4, 5, "
                           '6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n'
                           "    b'hello world'\n"
                           '\n'
                           '    # Checking\n'
                           "    >> rsc.check(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    [False]\n'
                           "    >> rmes, rmesecc = rsc.decode(b'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=')\n"
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    # To use longer chunks or bigger values than 255 (may be very slow)\n'
                           '    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n'
                           '    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n'
                           "    >> mes = 'a' * (4095-12)\n"
                           '    >> mesecc = rsc.encode(mes)\n'
                           '    >> mesecc[2] = 1\n'
                           '    >> mesecc[-1] = 1\n'
                           '    >> rmes, rmesecc = rsc.decode(mesecc)\n'
                           '    >> rsc.check(mesecc)\n'
                           '    [False]\n'
                           '    >> rsc.check(rmesecc)\n'
                           '    [True]\n'
                           '\n'
                           '    If you want full control, you can skip the API and directly use the library as-is. '
                           "Here's how:\n"
                           '\n'
                           '    First you need to init the precomputed tables:\n'
                           '    >> import reedsolo as rs\n'
                           '    >> rs.init_tables(0x11d)\n'
                           '    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please '
                           'check that your prime polynomial is correct for your field.\n'
                           '    Pro tip2: by default, you can only encode messages of max length and max symbol '
                           'value = 256. If you want to encode bigger messages,\n'
                           '    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 '
                           '= max length 2^12 = 4096):\n'
                           '    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n'
                           '    >> rs.init_tables(c_exp=12, prim=prim)\n'
                           '    \n'
                           "    Let's define our RS message and ecc size:\n"
                           '    >> n = 255  # length of total message+ecc\n'
                           '    >> nsym = 12  # length of ecc\n'
                           '    >> mes = "a" * (n-nsym)  # generate a sample message\n'
                           '\n'
                           '    To optimize, you can precompute the generator polynomial:\n'
                           '    >> gen = rs.rs_generator_poly_all(n)\n'
                           '\n'
                           '    Then to encode:\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n'
                           '\n'
                           "    Let's tamper our message:\n"
                           '    >> mesecc[1] = 0\n'
                           '\n'
                           '    To decode:\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n'
                           '    Note that both the message and the ecc are corrected (if possible of course).\n'
                           '    Pro tip: if you know a few erasures positions, you can specify them in a list '
                           '`erase_pos` to double the repair power. But you can also just specify an empty list.\n'
                           '\n'
                           '    If the decoding fails, it will normally automatically check and raise a '
                           'ReedSolomonError exception that you can handle.\n'
                           '    However if you want to manually check if the repaired message is correct, you can '
                           'do so:\n'
                           '    >> rs.rs_check(rmes + recc, nsym)\n'
                           '\n'
                           '    Note: if you want to use multiple reedsolomon with different parameters, you need '
                           'to backup the globals and restore them before calling reedsolo functions:\n'
                           '    >> rs.init_tables()\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n'
                           '    Then at anytime, you can do:\n'
                           '    >> global gf_log, gf_exp, field_charac\n'
                           '    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n'
                           '    >> mesecc = rs.rs_encode_msg(mes, nsym)\n'
                           '    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n'
                           '    The globals backup is not necessary if you use RSCodec, it will be automatically '
                           'managed.\n'
                           '\n'
                           "    Read the sourcecode's comments for more info about how it works, and for the "
                           'various parameters you can setup if\n'
                           '    you need to interface with other RS codecs.\n'
                           '\n'
                           "'''\n"
                           '\n'
                           '# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials '
                           'inside lists throughout the code and functions (because for now there are a lot of '
                           'list reversing in order to make it work, you never know the order of a polynomial, ie, '
                           'if the first coefficient is the major degree or the constant term...).\n'
                           '\n'
                           'import itertools\n'
                           'import math\n'
                           '\n'
                           '\n'
                           '################### INIT and stuff ###################\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    bytearray\n'
                           '    _bytearray = bytearray\n'
                           'except NameError:  # pragma: no cover\n'
                           '    from array import array\n'
                           '    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n'
                           "        '''Simple bytearray replacement'''\n"
                           '        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '        if isinstance(obj, str):\n'
                           '            obj = [ord(ch) for ch in obj.encode(encoding)]\n'
                           '        elif isinstance(obj, int):\n'
                           '            obj = [0] * obj\n'
                           '        return array("B", obj)\n'
                           '\n'
                           'try:  # pragma: no cover\n'
                           '    # compatibility with Python 2.7\n'
                           '    xrange\n'
                           'except NameError:  # pragma: no cover\n'
                           '    # compatibility with Python 3+\n'
                           '    xrange = range\n'
                           '\n'
                           'class ReedSolomonError(Exception):\n'
                           '    pass\n'
                           '\n'
                           'gf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that '
                           'a simple multiplication of two numbers can be resolved without calling % 255. For more '
                           'infos on how to generate this extended exponentiation table, see paper: "Fast software '
                           'implementation of finite field operations", Cheng Huang and Lihao Xu, Washington '
                           'University in St. Louis, Tech. Rep (2003).\n'
                           'gf_log = _bytearray(256)\n'
                           'field_charac = int(2**8 - 1)\n'
                           '\n'
                           '################### GALOIS FIELD ELEMENTS MATHS ###################\n'
                           '\n'
                           'def rwh_primes1(n):\n'
                           '    # '
                           'http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n'
                           "    ''' Returns  a list of primes < n '''\n"
                           '    sieve = [True] * int(n/2)\n'
                           '    for i in xrange(3,int(n**0.5)+1,2):\n'
                           '        if sieve[int(i/2)]:\n'
                           '            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n'
                           '    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n'
                           '\n'
                           'def find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n'
                           "    '''Compute the list of prime polynomials for the given generator and galois field "
                           "characteristic exponent.'''\n"
                           '    # fast_primes will output less results but will be significantly faster.\n'
                           '    # single will output the first prime polynomial found, so if all you want is to '
                           'just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just '
                           'use that.\n'
                           '\n'
                           '    # A prime polynomial (necessarily irreducible) is necessary to reduce the '
                           'multiplications in the Galois Field, so as to avoid overflows.\n'
                           '    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for '
                           'GF(2^8) for example)? Because we need the values to be unique.\n'
                           '    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), '
                           'then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field '
                           'it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be '
                           'doubled (ie, next power of 2), which will give 256. Then we must reduce, because we '
                           'have overflowed above the maximum value of 255. But, if we modulo 255, this will '
                           'generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. '
                           "This is very bad, as it's then not anymore a bijection (ie, a non-zero value doesn't "
                           "have a unique index). That's why we can't just modulo 255, but we need another number "
                           'above 255, which is called the prime polynomial.\n'
                           '    # Why so much hassle? Because we are using precomputed look-up tables for '
                           'multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and '
                           'alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our '
                           'result. But just like in our original field we had 0,1,2,...,p-1 distinct unique '
                           'values, in our "LUT" field using alpha we must have unique distinct values (we don\'t '
                           'care that they are different from the original field as long as they are unique and '
                           "distinct). That's why we need to avoid duplicated values, and to avoid duplicated "
                           'values we need to use a prime irreducible polynomial.\n'
                           '\n'
                           '    # Here is implemented a bruteforce approach to find all these prime polynomials, '
                           'by generating every possible prime polynomials (ie, every integers between '
                           'field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we '
                           'reject the candidate prime polynomial if it duplicates even one value or if it '
                           'generates a value above field_charac (ie, cause an overflow).\n'
                           '    # Note that this algorithm is slow if the field is too big (above 12), because '
                           "it's an exhaustive search algorithm. There are probabilistic approaches, and almost "
                           'surely prime approaches, but there is no determistic polynomial time algorithm to find '
                           'irreducible monic polynomials. More info can be found at: '
                           'http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n'
                           '    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. '
                           'Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the '
                           'eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n'
                           '\n'
                           '    # Prepare the finite field characteristic (2^p - 1), this also represent the '
                           'maximum possible value in this field\n'
                           "    root_charac = 2 # we're in GF(2)\n"
                           '    field_charac = int(root_charac**c_exp - 1)\n'
                           '    field_charac_next = int(root_charac**(c_exp+1) - 1)\n'
                           '\n'
                           '    prim_candidates = []\n'
                           '    if fast_primes:\n'
                           '        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime '
                           'polynomials and check later if they really are irreducible\n'
                           '        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter '
                           'out too small primes\n'
                           '    else:\n'
                           '        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try '
                           'each possible prime polynomial, but skip even numbers (because divisible by 2 so '
                           'necessarily not irreducible)\n'
                           '\n'
                           '    # Start of the main loop\n'
                           '    correct_primes = []\n'
                           '    for prim in prim_candidates: # try potential candidates primitive irreducible '
                           'polys\n'
                           '        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was '
                           'already generated in the field (value at index x is set to 1) or not (set to 0 by '
                           'default)\n'
                           '        conflict = False # flag to know if there was at least one conflict\n'
                           '\n'
                           '        # Second loop, build the whole Galois Field\n'
                           '        x = 1\n'
                           '        for i in xrange(field_charac):\n'
                           '            # Compute the next value in the field (ie, the next power of '
                           'alpha/generator)\n'
                           '            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '            # Rejection criterion: if the value overflowed (above field_charac) or is '
                           'a duplicate of a previously generated power of alpha, then we reject this polynomial '
                           '(not prime)\n'
                           '            if x > field_charac or seen[x] == 1:\n'
                           '                conflict = True\n'
                           '                break\n'
                           '            # Else we flag this value as seen (to maybe detect future duplicates), and '
                           'we continue onto the next power of alpha\n'
                           '            else:\n'
                           '                seen[x] = 1\n'
                           '\n'
                           "        # End of the second loop: if there's no conflict (no overflow nor duplicated "
                           'value), this is a prime polynomial!\n'
                           '        if not conflict: \n'
                           '            correct_primes.append(prim)\n'
                           '            if single: return prim\n'
                           '\n'
                           '    # Return the list of all prime polynomials\n'
                           '    return correct_primes # you can use the following to print the hexadecimal '
                           'representation of each prime polynomial: print [hex(i) for i in correct_primes]\n'
                           '\n'
                           'def init_tables(prim=0x11d, generator=2, c_exp=8):\n'
                           "    '''Precompute the logarithm and anti-log tables for faster computation later, "
                           'using the provided primitive polynomial.\n'
                           '    These tables are used for multiplication/division since addition/substraction are '
                           'simple XOR operations inside GF of characteristic 2.\n'
                           '    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any '
                           'number b (the base or generator of the logarithm), then we can use any number b to '
                           'precompute logarithm and anti-log (exponentiation) tables to use for multiplying two '
                           'numbers x and y.\n'
                           "    That's why when we use a different base/generator number, the log and anti-log "
                           'tables are drastically different, but the resulting computations are the same given '
                           'any such tables.\n'
                           '    For more infos, see '
                           'https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n'
                           "    '''\n"
                           '    # generator is the generator number (the "increment" that will be used to walk '
                           'through the field by multiplication, this must be a prime number). This is basically '
                           'the base of the logarithm/anti-log tables. Also often noted "alpha" in academic '
                           'books.\n'
                           '    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it '
                           "can't represented as the product of two smaller polynomials). It's a polynomial in the "
                           "binary sense: each bit is a coefficient, but in fact it's an integer between "
                           'field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial '
                           'will be used to reduce the overflows back into the range of the Galois Field without '
                           'duplicating values (all values should be unique). See the function find_prime_polys() '
                           'and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n'
                           "    # note that the choice of generator or prime polynomial doesn't matter very much: "
                           'any two finite fields of size p^n have identical structure, even if they give the '
                           'individual elements different names (ie, the coefficients of the codeword will be '
                           'different, but the final result will be the same: you can always correct as many '
                           "errors/erasures with any choice for those parameters). That's why it makes sense to "
                           'refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as '
                           'one concept: GF(p^n). It can however impact sensibly the speed (because some '
                           'parameters will generate sparser tables).\n'
                           "    # c_exp is the exponent for the field's characteristic GF(2^c_exp)\n"
                           '\n'
                           '    # Redefine _bytearray() in case we need to support integers or messages of length '
                           '> 256\n'
                           '    global _bytearray\n'
                           '    if c_exp <= 8:\n'
                           '        _bytearray = bytearray\n'
                           '    else:\n'
                           '        from array import array\n'
                           '        def _bytearray(obj = 0, encoding = "latin-1"):\n'
                           "            '''Fake bytearray replacement, supporting int values above 255'''\n"
                           '            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 '
                           'characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at '
                           'vale 128)\n'
                           '            if isinstance(obj, str):  # obj is a string, convert to list of ints\n'
                           '                obj = obj.encode(encoding)\n'
                           '                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n'
                           '                    obj = [ord(chr) for chr in obj]\n'
                           '                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need '
                           "to convert to int for array.array('i', obj)\n"
                           '                    obj = [int(chr) for chr in obj]\n'
                           '                else:\n'
                           '                    raise(ValueError, "Type of object not recognized!")\n'
                           '            elif isinstance(obj, int):  # compatibility with list preallocation '
                           'bytearray(int)\n'
                           '                obj = [0] * obj\n'
                           '            elif isinstance(obj, bytes):\n'
                           '                obj = [int(b) for b in obj]\n'
                           "            # Else obj is a list of int, it's ok\n"
                           '            return array("i", obj)\n'
                           '\n'
                           '    # Init global tables\n'
                           '    global gf_exp, gf_log, field_charac\n'
                           '    field_charac = int(2**c_exp - 1)\n'
                           '    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first '
                           'two elements will always be [GF256int(1), generator]\n'
                           '    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus '
                           'unused\n'
                           '\n'
                           '    # For each possible value in the galois field 2^8, we will pre-compute the '
                           'logarithm and anti-logarithm (exponential) of this value\n'
                           '    # To do that, we generate the Galois Field F(2^p) by building a list starting with '
                           'the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, '
                           'α^2, ..., α^(p-1).\n'
                           '    x = 1\n'
                           '    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 '
                           'because of modulo: g^255==g^0 but either way, this does not change the later outputs '
                           '(ie, the ecc symbols will be the same either way)\n'
                           '        gf_exp[i] = x # compute anti-log for this value and store it in a table\n'
                           '        gf_log[x] = i # compute log at the same time\n'
                           '        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n'
                           '\n'
                           '        # If you use only generator==2 or a power of 2, you can use the following '
                           'which is faster than gf_mult_noLUT():\n'
                           '        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power '
                           'of 2^y)\n'
                           '        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n'
                           '            #x ^= prim # substract the primary polynomial to the current value '
                           '(instead of 255, so that we get a unique set made of coprime numbers), this is the '
                           'core of the tables generation\n'
                           '\n'
                           "    # Optimization: double the size of the anti-log table so that we don't need to mod "
                           '255 to stay inside the bounds (because we will mainly use this table for the '
                           'multiplication of two GF numbers, no more).\n'
                           '    for i in xrange(field_charac, field_charac * 2):\n'
                           '        gf_exp[i] = gf_exp[i - field_charac]\n'
                           '\n'
                           '    return [gf_log, gf_exp, field_charac]\n'
                           '\n'
                           'def gf_add(x, y):\n'
                           '    return x ^ y\n'
                           '\n'
                           'def gf_sub(x, y):\n'
                           '    return x ^ y # in binary galois field, substraction is just the same as addition '
                           '(since we mod 2)\n'
                           '\n'
                           'def gf_neg(x):\n'
                           '    return x\n'
                           '\n'
                           'def gf_inverse(x):\n'
                           '    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n'
                           '\n'
                           'def gf_mul(x, y):\n'
                           '    if x == 0 or y == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_div(x, y):\n'
                           '    if y == 0:\n'
                           '        raise ZeroDivisionError()\n'
                           '    if x == 0:\n'
                           '        return 0\n'
                           '    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n'
                           '\n'
                           'def gf_pow(x, power):\n'
                           '    return gf_exp[(gf_log[x] * power) % field_charac]\n'
                           '\n'
                           'def gf_mult_noLUT_slow(x, y, prim=0):\n'
                           "    '''Multiplication in Galois Fields without using a precomputed look-up table (and "
                           "thus it's slower) by using the standard carry-less multiplication + modular reduction "
                           "using an irreducible prime polynomial.'''\n"
                           '\n'
                           '    ### Define bitwise carry-less operations as inner functions ###\n'
                           '    def cl_mult(x,y):\n'
                           "        '''Bitwise carry-less multiplication on integers'''\n"
                           '        z = 0\n'
                           '        i = 0\n'
                           '        while (y>>i) > 0:\n'
                           '            if y & (1<<i):\n'
                           '                z ^= x<<i\n'
                           '            i += 1\n'
                           '        return z\n'
                           '\n'
                           '    def bit_length(n):\n'
                           "        '''Compute the position of the most significant bit (1) of an integer. "
                           "Equivalent to int.bit_length()'''\n"
                           '        bits = 0\n'
                           '        while n >> bits: bits += 1\n'
                           '        return bits\n'
                           ' \n'
                           '    def cl_div(dividend, divisor=None):\n'
                           "        '''Bitwise carry-less long division on integers and returns the remainder'''\n"
                           '        # Compute the position of the most significant bit for each integers\n'
                           '        dl1 = bit_length(dividend)\n'
                           '        dl2 = bit_length(divisor)\n'
                           '        # If the dividend is smaller than the divisor, just exit\n'
                           '        if dl1 < dl2:\n'
                           '            return dividend\n'
                           '        # Else, align the most significant 1 of the divisor to the most significant 1 '
                           'of the dividend (by shifting the divisor)\n'
                           '        for i in xrange(dl1-dl2,-1,-1):\n'
                           '            # Check that the dividend is divisible (useless for the first iteration '
                           'but important for the next ones)\n'
                           '            if dividend & (1 << i+dl2-1):\n'
                           '                # If divisible, then shift the divisor to align the most significant '
                           'bits and XOR (carry-less substraction)\n'
                           '                dividend ^= divisor << i\n'
                           '        return dividend\n'
                           ' \n'
                           '    ### Main GF multiplication routine ###\n'
                           ' \n'
                           '    # Multiply the gf numbers\n'
                           '    result = cl_mult(x,y)\n'
                           '    # Then do a modular reduction (ie, remainder from the division) with an '
                           'irreducible primitive polynomial so that it stays inside GF bounds\n'
                           '    if prim > 0:\n'
                           '        result = cl_div(result, prim)\n'
                           ' \n'
                           '    return result\n'
                           '\n'
                           'def gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n'
                           "    '''Galois Field integer multiplication using Russian Peasant Multiplication "
                           'algorithm (faster than the standard multiplication + modular reduction).\n'
                           '    If prim is 0 and carryless=False, then the function produces the result for a '
                           'standard integers multiplication (no carry-less arithmetics nor modular '
                           "reduction).'''\n"
                           '    r = 0\n'
                           '    while y: # while y is above 0\n'
                           '        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the '
                           "corresponding x to r (the sum of all x's corresponding to odd y's will give the final "
                           "product). Note that since we're in GF(2), the addition is in fact an XOR (very "
                           'important because in GF(2) the multiplication and additions are carry-less, thus it '
                           'changes the result!).\n'
                           '        y = y >> 1 # equivalent to y // 2\n'
                           '        x = x << 1 # equivalent to x*2\n'
                           '        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 '
                           'then apply modular reduction using the primitive polynomial (we just substract, but '
                           'since the primitive number can be above 256 then we directly XOR).\n'
                           '\n'
                           '    return r\n'
                           '\n'
                           '\n'
                           '################### GALOIS FIELD POLYNOMIALS MATHS ###################\n'
                           '\n'
                           'def gf_poly_scale(p, x):\n'
                           '    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n'
                           '\n'
                           'def gf_poly_add(p, q):\n'
                           '    r = _bytearray( max(len(p), len(q)) )\n'
                           '    r[len(r)-len(p):len(r)] = p\n'
                           '    #for i in xrange(len(p)):\n'
                           '        #r[i + len(r) - len(p)] = p[i]\n'
                           '    for i in xrange(len(q)):\n'
                           '        r[i + len(r) - len(q)] ^= q[i]\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul(p, q):\n'
                           "    '''Multiply two polynomials, inside Galois Field (but the procedure is generic). "
                           "Optimized function by precomputation of log.'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Precompute the logarithm of p\n'
                           '    lp = [gf_log[p[i]] for i in xrange(len(p))]\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        qj = q[j] # optimization: load the coefficient once\n'
                           '        if qj != 0: # log(0) is undefined, we need to check that\n'
                           '            lq = gf_log[qj] # Optimization: precache the logarithm of the current '
                           'coefficient of q\n'
                           '            for i in xrange(len(p)):\n'
                           '                if p[i] != 0: # log(0) is undefined, need to check that...\n'
                           '                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = '
                           'gf_add(r[i+j], gf_mul(p[i], q[j]))\n'
                           '    return r\n'
                           '\n'
                           'def gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials '
                           "without precomputation, but thus it's slower\n"
                           "    '''Multiply two polynomials, inside Galois Field'''\n"
                           '    # Pre-allocate the result array\n'
                           '    r = _bytearray(len(p) + len(q) - 1)\n'
                           '    # Compute the polynomial multiplication (just like the outer product of two '
                           'vectors, we multiply each coefficients of p with all coefficients of q)\n'
                           '    for j in xrange(len(q)):\n'
                           '        for i in xrange(len(p)):\n'
                           '            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], '
                           "gf_mul(p[i], q[j])) -- you can see it's your usual polynomial multiplication\n"
                           '    return r\n'
                           '\n'
                           'def gf_poly_neg(poly):\n'
                           "    '''Returns the polynomial with all coefficients negated. In GF(2^p), negation does "
                           "not change the coefficient, so we return the polynomial as-is.'''\n"
                           '    return poly\n'
                           '\n'
                           'def gf_poly_div(dividend, divisor):\n'
                           "    '''Fast polynomial division by using Extended Synthetic Division and optimized for "
                           "GF(2^p) computations (doesn't work with standard polynomials outside of this galois "
                           "field).'''\n"
                           '    # CAUTION: this function expects polynomials to follow the opposite convention at '
                           'decoding: the terms must go from the biggest to lowest degree (while most other '
                           'functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, '
                           '2, 1], NOT [1, 2, 5]\n'
                           '\n'
                           '    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the '
                           'ecc bytes will be computed\n'
                           '    #normalizer = divisor[0] # precomputing for performance\n'
                           '    for i in xrange(len(dividend) - (len(divisor)-1)):\n'
                           '        #msg_out[i] /= normalizer # for general polynomial division (when polynomials '
                           'are non-monic), the usual way of using synthetic division is to divide the divisor '
                           'g(x) with its leading coefficient (call it a). In this implementation, this means:we '
                           'need to compute: coef = msg_out[i] / gen[0]. For more infos, see '
                           'http://en.wikipedia.org/wiki/Synthetic_division\n'
                           '        coef = msg_out[i] # precaching\n'
                           '        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly '
                           "(and it's also a good optimization). In fact if you remove it, it should still work "
                           "because gf_mul() will take care of the condition. But it's still a good practice to "
                           'put the condition here.\n'
                           '            for j in xrange(1, len(divisor)): # in synthetic division, we always skip '
                           "the first coefficient of the divisior, because it's only used to normalize the "
                           'dividend coefficient\n'
                           '                if divisor[j] != 0: # log(0) is undefined\n'
                           '                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the '
                           'more mathematically correct (but xoring directly is faster): msg_out[i + j] += '
                           '-divisor[j] * coef\n'
                           '\n'
                           '    # The resulting msg_out contains both the quotient and the remainder, the '
                           'remainder being the size of the divisor (the remainder has necessarily the same degree '
                           "as the divisor -- not length but degree == length-1 -- since it's what we couldn't "
                           'divide from the dividend), so we compute the index where this separation is, and '
                           'return the quotient and remainder.\n'
                           '    separator = -(len(divisor)-1)\n'
                           '    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n'
                           '\n'
                           'def gf_poly_square(poly):  # pragma: no cover\n'
                           "    '''Linear time implementation of polynomial squaring. For details, see paper: "
                           '"A fast software implementation for arithmetic operations in GF (2n)". De Win, E., '
                           'Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In '
                           "Advances in Cryptology - Asiacrypt'96 (pp. 65-76). Springer Berlin Heidelberg.'''\n"
                           '    length = len(poly)\n'
                           '    out = _bytearray(2*length - 1)\n'
                           '    for i in xrange(length-1):\n'
                           '        p = poly[i]\n'
                           '        k = 2*i\n'
                           '        if p != 0:\n'
                           '            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo '
                           '(2^r)-1 since gf_exp is duplicated up to 510.\n'
                           '            out[k] = gf_exp[2*gf_log[p]]\n'
                           '        #else: # not necessary since the output is already initialized to an array of '
                           '0\n'
                           '            #out[k] = 0\n'
                           '    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n'
                           '    if out[0] == 0: out[0] = 2*poly[1] - 1\n'
                           '    return out\n'
                           '\n'
                           'def gf_poly_eval(poly, x):\n'
                           "    '''Evaluates a polynomial in GF(2^p) given the value for x. This is based on "
                           "Horner's scheme for maximum efficiency.'''\n"
                           '    y = poly[0]\n'
                           '    for i in xrange(1, len(poly)):\n'
                           '        y = gf_mul(y, x) ^ poly[i]\n'
                           '    return y\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON ENCODING ###################\n'
                           '\n'
                           'def rs_generator_poly(nsym, fcr=0, generator=2):\n'
                           "    '''Generate an irreducible generator polynomial (necessary to encode a message "
                           "into Reed-Solomon)'''\n"
                           '    g = _bytearray([1])\n'
                           '    for i in xrange(nsym):\n'
                           '        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n'
                           '    return g\n'
                           '\n'
                           'def rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n'
                           "    '''Generate all irreducible generator polynomials up to max_nsym (usually you can "
                           'use n, the length of the message+ecc). Very useful to reduce processing time if you '
                           "want to encode using variable schemes and nsym rates.'''\n"
                           '    g_all = {}\n'
                           '    g_all[0] = g_all[1] = _bytearray([1])\n'
                           '    for nsym in xrange(max_nsym):\n'
                           '        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n'
                           '    return g_all\n'
                           '\n'
                           'def rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Simple Reed-Solomon encoding (mainly an example for you to understand how it "
                           "works, because it's slower than the inlined function below)'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    # Pad the message, then divide it by the irreducible generator polynomial\n'
                           '    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n'
                           '    # The remainder is our RS code! Just append it to our original message to get our '
                           'full codeword (this represents a polynomial of max 256 terms)\n'
                           '    msg_out = msg_in + remainder\n'
                           '    # Return the codeword\n'
                           '    return msg_out\n'
                           '\n'
                           'def rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n'
                           "    '''Reed-Solomon main encoding function, using polynomial division (Extended "
                           'Synthetic Division, the fastest algorithm available to my knowledge), better explained '
                           "at http://research.swtch.com/field'''\n"
                           '    global field_charac\n'
                           '    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i '
                           'when max is %i)" % (len(msg_in)+nsym, field_charac))\n'
                           '    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n'
                           '\n'
                           '    msg_in = _bytearray(msg_in)\n'
                           '    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the '
                           'values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc '
                           'symbols).\n'
                           '\n'
                           '    # Precompute the logarithm of every items in the generator\n'
                           '    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n'
                           '\n'
                           '    # Extended synthetic division main loop\n'
                           '    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is '
                           'about 2x faster)\n'
                           '    for i in xrange(len(msg_in)):\n'
                           "        coef = msg_out[i] # Note that it's msg_out here, not msg_in. Thus, we reuse "
                           'the updated value at each iteration (this is how Synthetic Division works: instead of '
                           'storing in a temporary register the intermediate values, we directly commit them to '
                           'the output).\n'
                           '        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial '
                           'division (when polynomials are non-monic), the usual way of using synthetic division '
                           'is to divide the divisor g(x) with its leading coefficient (call it a). In this '
                           'implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n'
                           '        if coef != 0: # log(0) is undefined, so we need to manually check for this '
                           "case. There's no need to check the divisor here because we know it can't be 0 since we "
                           'generated it.\n'
                           '            lcoef = gf_log[coef] # precaching\n'
                           '\n'
                           '            for j in xrange(1, len(gen)): # in synthetic division, we always skip the '
                           "first coefficient of the divisior, because it's only used to normalize the dividend "
                           'coefficient (which is here useless since the divisor, the generator polynomial, is '
                           'always monic)\n'
                           '                #if gen[j] != 0: # log(0) is undefined so we need to check that, but '
                           "it slow things down in fact and it's useless in our case (reed-solomon encoding) since "
                           'we know that all coefficients in the generator are not 0\n'
                           '                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent '
                           'to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we '
                           "are in GF256, it's equivalent to an addition and to an XOR). In other words, this is "
                           'simply a "multiply-accumulate operation"\n'
                           '\n'
                           '    # Recopy the original message bytes (overwrites the part where the quotient was '
                           'computed)\n'
                           '    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is '
                           'msg_in padded with [0]*nsym\n'
                           '    return msg_out\n'
                           '\n'
                           '\n'
                           '################### REED-SOLOMON DECODING ###################\n'
                           '\n'
                           'def rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Given the received codeword msg and the number of error correcting symbols "
                           '(nsym), computes the syndromes polynomial.\n'
                           "    Mathematically, it's essentially equivalent to a Fourrier Transform (Chien search "
                           'being the inverse).\n'
                           "    '''\n"
                           '    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). '
                           'This effectively shifts the syndrome, and will shift every computations depending on '
                           'the syndromes (such as the errors locator polynomial, errors evaluator polynomial, '
                           'etc. but not the errors positions).\n'
                           '    # This is not necessary as anyway syndromes are defined such as there are only '
                           'non-zero coefficients (the only 0 is the shift of the constant here) and subsequent '
                           'computations will/must account for the shift by skipping the first iteration (eg, the '
                           'often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt '
                           'every subsequent computations to start from 0 instead of 1.\n'
                           '    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n'
                           '\n'
                           'def rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list '
                           'of the positions of the errors/erasures/errata\n'
                           "    '''Forney algorithm, computes the values (error magnitude) to correct the input "
                           "message.'''\n"
                           '    global field_charac\n'
                           '    msg = _bytearray(msg_in)\n'
                           '    # calculate errata locator polynomial to correct both errors and erasures (by '
                           'combining the errors positions given by the error locator polynomial found by BM with '
                           'the erasures positions given by caller)\n'
                           '    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to '
                           'coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it '
                           'will become [len(msg)-1, len(msg)-2, len(msg) -3])\n'
                           '    err_loc = rs_find_errata_locator(coef_pos, generator)\n'
                           '    # calculate errata evaluator polynomial (often called Omega or Gamma in academic '
                           'papers)\n'
                           '    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n'
                           '\n'
                           '    # Second part of Chien search to get the error location polynomial X from the '
                           'error positions in err_pos (the roots of the error locator polynomial, ie, where it '
                           'evaluates to 0)\n'
                           '    X = [] # will store the position of the errors\n'
                           '    for i in xrange(len(coef_pos)):\n'
                           '        l = field_charac - coef_pos[i]\n'
                           '        X.append( gf_pow(generator, -l) )\n'
                           '\n'
                           '    # Forney algorithm: compute the magnitudes\n'
                           '    E = _bytearray(len(msg)) # will store the values that need to be corrected '
                           '(substracted) to the message containing errors. This is sometimes called the error '
                           'magnitude polynomial.\n'
                           '    Xlength = len(X)\n'
                           '    for i, Xi in enumerate(X):\n'
                           '\n'
                           '        Xi_inv = gf_inverse(Xi)\n'
                           '\n'
                           '        # Compute the formal derivative of the error locator polynomial (see Blahut, '
                           'Algebraic codes for data transmission, pp 196-197).\n'
                           '        # the formal derivative of the errata locator is used as the denominator of '
                           'the Forney Algorithm, which simply says that the ith error value is given by '
                           'error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See '
                           'Blahut, Algebraic codes for data transmission, pp 196-197.\n'
                           '        err_loc_prime_tmp = []\n'
                           '        for j in xrange(Xlength):\n'
                           '            if j != i:\n'
                           '                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n'
                           '        # compute the product, which is the denominator of the Forney algorithm '
                           '(errata locator derivative)\n'
                           '        err_loc_prime = 1\n'
                           '        for coef in err_loc_prime_tmp:\n'
                           '            err_loc_prime = gf_mul(err_loc_prime, coef)\n'
                           '        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, '
                           '1)\n'
                           '\n'
                           '        # Test if we could find the errata locator, else we raise an Exception '
                           '(because else since we divide y by err_loc_prime to compute the magnitude, we will get '
                           'a ZeroDivisionError exception otherwise)\n'
                           '        if err_loc_prime == 0:\n'
                           '            raise ReedSolomonError("Decoding failed: Forney algorithm could not '
                           'properly detect where the errors are located (errata locator prime is 0).")\n'
                           '\n'
                           '        # Compute y (evaluation of the errata evaluator polynomial)\n'
                           '        # This is a more faithful translation of the theoretical equation contrary to '
                           'the old forney method. Here it is exactly copy/pasted from the included presentation '
                           'decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) '
                           "(in the paper it's for j in s, but it's useless when len(X) < s because we compute "
                           'neutral terms 1 for nothing, and wrong when correcting more than s erasures or '
                           'erasures+errors since it prevents computing all required terms).\n'
                           '        # Thus here this method works with erasures too because firstly we fixed the '
                           "equation to be like the theoretical one (don't know why it was modified in "
                           "_old_forney(), if it's an optimization, it doesn't enhance anything), and secondly "
                           'because we removed the product bound on s, which prevented computing errors and '
                           'erasures above the s=(n-k)//2 bound.\n'
                           '        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm '
                           '(errata evaluator evaluated)\n'
                           '        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n'
                           '        \n'
                           '        # Compute the magnitude\n'
                           '        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, '
                           'calculated by the Forney algorithm (an equation in fact): dividing the errata '
                           'evaluator with the errata locator derivative gives us the errata magnitude (ie, value '
                           'to repair) the ith symbol\n'
                           '        E[err_pos[i]] = magnitude # store the magnitude for this error into the '
                           'magnitude polynomial\n'
                           '\n'
                           '    # Apply the correction of values to get our message corrected! (note that the ecc '
                           'bytes also gets corrected!)\n'
                           "    # (this isn't the Forney algorithm, we just apply the result of decoding here)\n"
                           '    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct '
                           'message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is '
                           "replaced by XOR since it's equivalent in GF(2^p)). So in fact here we substract from "
                           'the received message the errors magnitude, which logically corrects the value to what '
                           'it should be.\n'
                           '    return msg\n'
                           '\n'
                           'def rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n'
                           "    '''Find error/errata locator and evaluator polynomials with Berlekamp-Massey "
                           "algorithm'''\n"
                           '    # The idea is that BM will iteratively estimate the error locator polynomial.\n'
                           '    # To do this, it will compute a Discrepancy term called Delta, which will tell us '
                           'if the error locator polynomial needs an update or not\n'
                           "    # (hence why it's called discrepancy: it tells us when we are getting off board "
                           'from the correct value).\n'
                           '\n'
                           '    # Init the polynomials\n'
                           '    if erase_loc: # if the erasure locator polynomial is supplied, we init with its '
                           'value, so that we include erasures in the final locator polynomial\n'
                           '        err_loc = _bytearray(erase_loc)\n'
                           '        old_loc = _bytearray(erase_loc)\n'
                           '    else:\n'
                           '        err_loc = _bytearray([1]) # This is the main variable we want to fill, also '
                           'called Sigma in other notations or more formally the errors/errata locator '
                           'polynomial.\n'
                           '        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the '
                           'errata locator polynomial of the previous iteration in order to update other necessary '
                           'variables.\n'
                           '    #L = 0 # update flag variable, not needed here because we use an alternative '
                           'equivalent way of checking if update is needed (but using the flag could potentially '
                           'be faster depending on if using length(list) is taking linear time in your language, '
                           "here in Python it's constant so it's as fast.\n"
                           '\n'
                           '    # Fix the syndrome shifting: when computing the syndrome, some implementations may '
                           'prepend a 0 coefficient for the lowest degree term (the constant). This is a case of '
                           'syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I '
                           "don't know what purpose serves this shifting). If that's the case, then we need to "
                           'account for the syndrome shifting when we use the syndrome such as inside BM, by '
                           'skipping those prepended coefficients.\n'
                           '    # Another way to detect the shifting is to detect the 0 coefficients: by '
                           'definition, a syndrome does not contain any 0 coefficient (except if there are no '
                           "errors/erasures, in this case they are all 0). This however doesn't work with the "
                           'modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, '
                           'leaving only the coefficients corresponding to errors.\n'
                           '    synd_shift = 0\n'
                           '    if len(synd) > nsym: synd_shift = len(synd) - nsym\n'
                           '\n'
                           '    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), '
                           'except when you input a partial erase_loc and using the full syndrome instead of the '
                           'Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail '
                           'badly with IndexError).\n'
                           '        if erase_loc: # if an erasures locator polynomial was provided to init the '
                           'errors locator polynomial, then we must skip the FIRST erase_count iterations (not the '
                           'last iterations, this is very important!)\n'
                           '            K = erase_count+i+synd_shift\n'
                           "        else: # if erasures locator is not provided, then either there's no erasures "
                           "to account or we use the Forney syndromes, so we don't need to use erase_count nor "
                           'erase_loc (the erasures have been trimmed out of the Forney syndromes).\n'
                           '            K = i+synd_shift\n'
                           '\n'
                           '        # Compute the discrepancy Delta\n'
                           '        # Here is the close-to-the-books operation to compute the discrepancy Delta: '
                           "it's a simple polynomial multiplication of error locator with the syndromes, and then "
                           'we get the Kth element.\n'
                           '        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be '
                           "gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it's not "
                           'absolutely necessary to correctly decode.\n'
                           "        # But this can be optimized: since we only need the Kth element, we don't need "
                           'to compute the polynomial multiplication for any other element but the Kth. Thus to '
                           'optimize, we compute the polymul only at the item we need, skipping the rest (avoiding '
                           'a nested loop, thus we are linear time instead of quadratic).\n'
                           '        # This optimization is actually described in several figures of the book '
                           '"Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge '
                           'university press.\n'
                           '        delta = synd[K]\n'
                           '        for j in xrange(1, len(err_loc)):\n'
                           '            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called '
                           'discrepancy. Here we do a partial polynomial multiplication (ie, we compute the '
                           'polynomial multiplication only for the term of degree K). Should be equivalent to '
                           'brownanrs.polynomial.mul_at().\n'
                           '        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n'
                           '\n'
                           '        # Shift polynomials to compute the next degree\n'
                           '        old_loc = old_loc + _bytearray([0])\n'
                           '\n'
                           '        # Iteratively estimate the errata locator and evaluator polynomials\n'
                           "        if delta != 0: # Update only if there's a discrepancy\n"
                           '            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined '
                           'because rule A just says that we skip any modification for this iteration)\n'
                           '            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as '
                           'long as L is correctly computed\n'
                           '                # Computing errata locator polynomial Sigma\n'
                           '                new_loc = gf_poly_scale(old_loc, delta)\n'
                           '                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we '
                           'are doing err_loc * 1/delta = err_loc // delta\n'
                           '                err_loc = new_loc\n'
                           '                # Update the update flag\n'
                           "                #L = K - L # the update flag L is tricky: in Blahut's schema, it's "
                           'mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this '
                           'function, if you forgot to do `- erase_count` it would lead to correcting only '
                           '2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this '
                           'latest draft, this will lead to a wrong decoding in some cases where it should '
                           'correctly decode! Thus you should try with and without `- erase_count` to update L on '
                           'your own implementation and see which one works OK without producing wrong decoding '
                           'failures.\n'
                           '\n'
                           '            # Update with the discrepancy\n'
                           '            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n'
                           '\n'
                           "    # Check if the result is correct, that there's not too many errors to correct\n"
                           '    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, '
                           'else errs will not be of the correct size\n'
                           '    errs = len(err_loc) - 1\n'
                           '    if (errs-erase_count) * 2 + erase_count > nsym:\n'
                           '        raise ReedSolomonError("Too many errors to correct")\n'
                           '\n'
                           '    return err_loc\n'
                           '\n'
                           'def rs_find_errata_locator(e_pos, generator=2):\n'
                           "    '''Compute the erasures/errors/errata locator polynomial from the "
                           'erasures/errors/errata positions (the positions must be relative to the x coefficient, '
                           'eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being '
                           'the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients '
                           'are reversed since the ecc characters are placed as the first coefficients of the '
                           'polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] '
                           "= erasures_loc to be specified as an argument.'''\n"
                           '    # See: '
                           'http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf '
                           'and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of '
                           'Research and development 23.3 (1979): 299-315. '
                           'http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and '
                           'also a MatLab implementation here: '
                           'http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n'
                           '    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the '
                           'multiplication starts correctly without nulling any term\n'
                           '    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for '
                           'i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in '
                           "this library it's gf(3)). To generate c*x where c is a constant, we simply generate a "
                           'Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient '
                           'for x^1.\n'
                           '    for i in e_pos:\n'
                           '        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, '
                           'i), 0]) )\n'
                           '    return e_loc\n'
                           '\n'
                           'def rs_find_error_evaluator(synd, err_loc, nsym):\n'
                           "    '''Compute the error (or erasures if you supply sigma=erasures locator polynomial, "
                           'or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata '
                           'locator Sigma. Omega is already computed at the same time as Sigma inside the '
                           'Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute '
                           'Omega afterwards using this method, or just ensure that Omega computed by BM is '
                           "correct given Sigma.'''\n"
                           '    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n'
                           '    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # '
                           'first multiply syndromes * errata_locator, then do a polynomial division to truncate '
                           'the polynomial to the required length\n'
                           '\n'
                           '    # Faster way that is equivalent\n'
                           '    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the '
                           'errata locator polynomial\n'
                           '    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of '
                           'the length we want, which is equivalent to slicing the list (which represents the '
                           'polynomial)\n'
                           '\n'
                           '    return remainder\n'
                           '\n'
                           'def rs_find_errors(err_loc, nmess, generator=2):\n'
                           "    '''Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce "
                           "trial, this is a sort of Chien's search (but less efficient, Chien's search is a way "
                           "to evaluate the polynomial such that each evaluation only takes constant time).'''\n"
                           '    # nmess = length of whole codeword (message + ecc symbols)\n'
                           '    errs = len(err_loc) - 1\n'
                           '    err_pos = []\n'
                           '    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here '
                           'we optimize to just check the interesting symbols\n'
                           "        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It's a 0? Bingo, it's a "
                           'root of the error locator polynomial, in other terms this is the location of an error\n'
                           '            err_pos.append(nmess - 1 - i)\n'
                           '    # Sanity check: the number of errors/errata positions found should be exactly the '
                           'same as the length of the errata locator polynomial\n'
                           '    if len(err_pos) != errs:\n'
                           '        # TODO: to decode messages+ecc with length n > 255, we may try to use a '
                           'bruteforce approach: the correct positions ARE in the final array j, but the problem '
                           "is because we are above the Galois Field's range, there is a wraparound so that for "
                           'example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because '
                           "258 % 255 == 3, same for the other values), so we can't discriminate. The issue is "
                           'that fixing any errs_nb errors among those will always give a correct output message '
                           '(in the sense that the syndrome will be all 0), so we may not even be able to check if '
                           "that's correct or not, so I'm not sure the bruteforce approach may even be possible.\n"
                           '        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the '
                           'errata locator polynomial!")\n'
                           '    return err_pos\n'
                           '\n'
                           'def rs_forney_syndromes(synd, pos, nmess, generator=2):\n'
                           '    # Compute Forney syndromes, which computes a modified syndromes to compute only '
                           'errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which '
                           'allows to correct the message based on the location of errors.\n'
                           '    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree '
                           'positions (instead of the erasures positions)\n'
                           '\n'
                           '    # Optimized method, all operations are inlined\n'
                           '    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is '
                           'always 0 by definition\n'
                           '    for i in xrange(len(pos)):\n'
                           '        x = gf_pow(generator, erase_pos_reversed[i])\n'
                           '        for j in xrange(len(fsynd) - 1):\n'
                           '            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n'
                           "        #fsynd.pop() # useless? it doesn't change the results of computations to leave "
                           'it there\n'
                           '\n'
                           '    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * '
                           'synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as '
                           'many books do not even mention it (and it works without trimming)\n'
                           '    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A '
                           'single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, '
                           "IEEE International Conference on ICASSP'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n"
                           '    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # '
                           'computing the erasures locator polynomial\n'
                           '    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome '
                           'to get the untrimmed forney syndrome\n'
                           '    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are '
                           'useless. Seems to be not necessary, but this reduces the computation time later in BM '
                           "(thus it's an optimization).\n"
                           '\n'
                           '    return fsynd\n'
                           '\n'
                           'def rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        # Note that it is in fact possible to encode/decode messages that are longer '
                           'than field_charac, but because this will be above the field, this will generate more '
                           'error positions during Chien Search than it should, because this will generate '
                           "duplicate values, which should normally be prevented thank's to the prime polynomial "
                           "reduction (eg, because it can't discriminate between error at position 1 or 256, both "
                           "being exactly equal under galois field 2^8). So it's really not advised to do it, but "
                           "it's possible (but then you're not guaranted to be able to correct any error/erasure "
                           'on symbols with a position above the length of field_charac -- if you really need a '
                           'bigger message without chunking, then you should better enlarge c_exp so that you get '
                           'a bigger field).\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures to correct (beyond the Singleton bound)\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n'
                           '\n'
                           '    # Find errors locations\n'
                           '    if only_erasures:\n'
                           '        err_pos = []\n'
                           '    else:\n'
                           '        # compute the Forney syndromes, which hide the erasures from the original '
                           'syndrome (so that BM will just have to deal with errors, not erasures)\n'
                           '        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n'
                           '        # compute the error locator polynomial using Berlekamp-Massey\n'
                           '        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n'
                           '        # locate the message errors using Chien search (or bruteforce search)\n'
                           '        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n'
                           '        if err_pos is None:\n'
                           '            raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # Find errors values and apply them to correct the message\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # '
                           'note that we here use the original syndrome, not the forney syndrome (because we will '
                           'correct both errors and erasures, so we need the full syndrome)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, '
                           'only_erasures=False):\n'
                           "    '''Reed-Solomon main decoding function, without using the modified Forney "
                           "syndromes'''\n"
                           '    global field_charac\n'
                           '    if len(msg_in) > field_charac:\n'
                           '        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), '
                           'field_charac))\n'
                           '\n'
                           '    msg_out = _bytearray(msg_in)     # copy of message\n'
                           '    # erasures: set them to null bytes for easier decoding (but this is not necessary, '
                           'they will be corrected anyway, but debugging will be easier with null bytes because '
                           'the error locator polynomial values will only depend on the errors locations, not '
                           'their values)\n'
                           '    if erase_pos is None:\n'
                           '        erase_pos = []\n'
                           '    else:\n'
                           '        for e_pos in erase_pos:\n'
                           '            msg_out[e_pos] = 0\n'
                           '    # check if there are too many erasures\n'
                           '    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n'
                           '    # prepare the syndrome polynomial using only errors (ie: errors = characters that '
                           "were either replaced by null byte or changed to another character, but we don't know "
                           'their positions)\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           "    # check if there's any error/erasure in the input codeword. If not (all syndromes "
                           'coefficients are 0), then just return the codeword as-is.\n'
                           '    if max(synd) == 0:\n'
                           '        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n'
                           '\n'
                           '    # prepare erasures locator and evaluator polynomials\n'
                           '    erase_loc = None\n'
                           '    #erase_eval = None\n'
                           '    erase_count = 0\n'
                           '    if erase_pos:\n'
                           '        erase_count = len(erase_pos)\n'
                           '        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n'
                           '        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n'
                           '        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, '
                           'len(erase_loc)-1)\n'
                           '\n'
                           '    # prepare errors/errata locator polynomial\n'
                           '    if only_erasures:\n'
                           '        err_loc = erase_loc[::-1]\n'
                           '        #err_eval = erase_eval[::-1]\n'
                           '    else:\n'
                           '        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, '
                           'erase_count=erase_count)\n'
                           '        err_loc = err_loc[::-1]\n'
                           '        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], '
                           'len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary '
                           'since we already compute it at the same time as the error locator poly in BM)\n'
                           '\n'
                           '    # locate the message errors\n'
                           '    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the '
                           'errata locator polynomial (ie: the positions of the errors/errata)\n'
                           '    if err_pos is None:\n'
                           '        raise ReedSolomonError("Could not locate error")\n'
                           '\n'
                           '    # compute errata evaluator and errata magnitude polynomials, then correct errors '
                           'and erasures\n'
                           '    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n'
                           '    # check if the final message is fully repaired\n'
                           '    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n'
                           '    if max(synd) > 0:\n'
                           '        raise ReedSolomonError("Could not correct message")\n'
                           '    # return the successfully decoded message\n'
                           '    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the '
                           'corrected ecc block so that the user can check(), and the position of errors to allow '
                           'for adaptive bitrate algorithm to check how the number of errors vary\n'
                           '\n'
                           'def rs_check(msg, nsym, fcr=0, generator=2):\n'
                           "    '''Returns true if the message + ecc has no error of false otherwise (may not "
                           'always catch a wrong decoding or a wrong message, particularly if there are too many '
                           "errors -- above the Singleton bound --, but it usually does)'''\n"
                           '    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n'
                           '\n'
                           '\n'
                           '#===================================================================================================\n'
                           '# API\n'
                           '#===================================================================================================\n'
                           'class RSCodec(object):\n'
                           "    '''\n"
                           '    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to '
                           'encode a\n'
                           '    (byte)string to include the RS correction code, and pass such an encoded '
                           '(byte)string to\n'
                           '    ``decode`` to extract the original message (if the number of errors allows for '
                           'correct decoding).\n'
                           '    The ``nsym`` argument is the length of the correction code, and it determines the '
                           'number of\n'
                           '    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n'
                           "    '''\n"
                           "    '''\n"
                           '    Modifications by rotorgit 2/3/2015:\n'
                           '    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n'
                           '    different primitive polynomial and non-zero first consecutive root (fcr).\n'
                           '    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n'
                           '    the class; leaving them out will default for previous values (0 and\n'
                           '    0x11d)\n'
                           "    '''\n"
                           '\n'
                           '    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, '
                           'single_gen=True):\n'
                           "        '''Initialize the Reed-Solomon codec. Note that different parameters change "
                           'the internal values (the ecc symbols, look-up table values, etc) but not the output '
                           'result (whether your message can be repaired or not, there is no influence of the '
                           'parameters).\n'
                           '        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n'
                           '        nsize : maximum length of each chunk. If higher than 255, will use a higher '
                           "Galois Field, but the algorithm's complexity and computational cost will raise "
                           'quadratically...\n'
                           '        single_gen : if you want to use the same RSCodec for different nsym parameters '
                           '(but nsize the same), then set single_gen = False.\n'
                           "        '''\n"
                           '\n'
                           '        # Auto-setup if galois field or message length is different than default '
                           '(exponent 8)\n'
                           '        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois '
                           'field, we resize the galois field\n'
                           '            # Get the next closest power of two\n'
                           '            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), '
                           '2))\n'
                           '        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n'
                           '            prim = find_prime_polys(generator=generator, c_exp=c_exp, '
                           'fast_primes=True, single=True)\n'
                           '            if nsize == 255:  # resize chunk size if not set\n'
                           '                nsize = int(2**c_exp - 1)\n'
                           '        if nsym >= nsize:\n'
                           "            raise ValueError('ECC symbols must be strictly less than the total message "
                           "length (nsym < nsize).')\n"
                           '\n'
                           '        # Memorize variables\n'
                           '        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be '
                           'r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate '
                           'r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and '
                           '0.5% erasures (5 symbols out of 10).\n'
                           '        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols '
                           "after encoding, for the message alone it's nsize-nsym)\n"
                           '        self.fcr = fcr # first consecutive root, can be any value between 0 and '
                           '(2**c_exp)-1\n'
                           '        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to '
                           'find a prime poly\n'
                           '        self.generator = generator # generator integer, must be prime\n'
                           "        self.c_exp = c_exp # exponent of the field's characteristic. This both defines "
                           "the maximum value per symbol and the maximum length of one chunk. By default it's "
                           "GF(2^8), do not change if you're not sure what it means.\n"
                           '\n'
                           '        # Initialize the look-up tables for easy and quick multiplication/division\n'
                           '        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, '
                           'c_exp)\n'
                           '        # Precompute the generator polynomials\n'
                           '        if single_gen:\n'
                           '            self.gen = {}\n'
                           '            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n'
                           '        else:\n'
                           '            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n'
                           '\n'
                           '    def chunk(self, data, chunksize):\n'
                           "        '''Split a long message into chunks'''\n"
                           '        for i in xrange(0, len(data), chunksize):\n'
                           '            # Split the long message in a chunk\n'
                           '            chunk = data[i:i+chunksize]\n'
                           '            yield chunk\n'
                           '\n'
                           '    def encode(self, data, nsym=None):\n'
                           "        '''Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the "
                           "length of the message because we use chunking'''\n"
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        enc = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize - self.nsym):\n'
                           '            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, '
                           'generator=self.generator, gen=self.gen[nsym]))\n'
                           '        return enc\n'
                           '\n'
                           '    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n'
                           "        '''Repair a message, whatever its size is, by using chunking. May return a "
                           'wrong result if number of errors > nsym.\n'
                           '        Note that it returns a couple of vars: the repaired messages, and the repaired '
                           'messages+ecc (useful for checking).\n'
                           '        Usage: rmes, rmesecc = RSCodec.decode(data).\n'
                           "        '''\n"
                           '        # erase_pos is a list of positions where you know (or greatly suspect at '
                           "least) there is an erasure (ie, wrong character but you know it's at this position). "
                           'Just input the list of all positions you know there are errors, and this method will '
                           'automatically split the erasures positions to attach to the corresponding data chunk.\n'
                           '\n'
                           '        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n'
                           '        global gf_log, gf_exp, field_charac\n'
                           '        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n'
                           '\n'
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        dec = _bytearray()\n'
                           '        dec_full = _bytearray()\n'
                           '        errata_pos_all = _bytearray()\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            # Extract the erasures for this chunk\n'
                           '            e_pos = []\n'
                           '            if erase_pos:\n'
                           '                # First extract the erasures for this chunk (all erasures below the '
                           'maximum chunk length)\n'
                           '                e_pos = [x for x in erase_pos if x < self.nsize]\n'
                           '                # Then remove the extract erasures from the big list and also '
                           "decrement all subsequent positions values by nsize (the current chunk's size) so as to "
                           'prepare the correct alignment for the next iteration\n'
                           '                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n'
                           '            # Decode/repair this chunk!\n'
                           '            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n'
                           '            dec.extend(rmes)\n'
                           '            dec_full.extend(rmes+recc)\n'
                           '            errata_pos_all.extend(errata_pos)\n'
                           '        return dec, dec_full, errata_pos_all\n'
                           '\n'
                           '    def check(self, data, nsym=None):\n'
                           "        '''Check if a message+ecc stream is not corrupted (or fully repaired). Note: "
                           "may return a wrong result if number of errors > nsym.'''\n"
                           '        if not nsym:\n'
                           '            nsym = self.nsym\n'
                           '        if isinstance(data, str):\n'
                           '            data = _bytearray(data)\n'
                           '        check = []\n'
                           '        for chunk in self.chunk(data, self.nsize):\n'
                           '            check.append(rs_check(chunk, nsym, fcr=self.fcr, '
                           'generator=self.generator))\n'
                           '        return check\n'
                           '\n'
                           '    def maxerrata(self, errors=None, erasures=None, verbose=False):\n'
                           "        '''Return the Singleton Bound for the current codec, which is the max number "
                           'of errata (errors and erasures) that the codec can decode/correct.\n'
                           '        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try '
                           'to raise an exception, but it may also not detect any problem with the message and '
                           'return 0 errors.\n'
                           '        Hence why you should use checksums if your goal is to detect errors (as '
                           'opposed to correcting them), as checksums have no bounds on the number of errors, the '
                           'only limitation being the probability of collisions.\n'
                           '        By default, return a tuple wth the maximum number of errors (2nd output) OR '
                           'erasures (2nd output) that can be corrected.\n'
                           '        If errors or erasures (not both) is specified as argument, computes the '
                           'remaining **simultaneous** correction capacity (eg, if errors specified, compute the '
                           'number of erasures that can be simultaneously corrected).\n'
                           "        Set verbose to True to get print a report.'''\n"
                           '        nsym = self.nsym\n'
                           '        # Compute the maximum number of errors OR erasures\n'
                           "        maxerrors = int(nsym/2)  # always floor the number, we can't correct half a "
                           "symbol, it's all or nothing\n"
                           '        maxerasures = nsym\n'
                           '        # Compute the maximum of simultaneous errors AND erasures\n'
                           '        if erasures is not None and erasures >= 0:\n'
                           '            # We know the erasures count, we want to know how many errors we can '
                           'correct simultaneously\n'
                           '            if erasures > maxerasures:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerrors = int((nsym-erasures)/2)\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (maxerrors, erasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return maxerrors, erasures\n'
                           '        if errors is not None and errors >= 0:\n'
                           '            # We know the errors count, we want to know how many erasures we can '
                           'correct simultaneously\n'
                           '            if errors > maxerrors:\n'
                           '                raise ReedSolomonError("Specified number of errors or erasures '
                           'exceeding the Singleton Bound!")\n'
                           '            maxerasures = int(nsym-(errors*2))\n'
                           '            if verbose:\n'
                           "                print('This codec can correct up to %i errors and %i erasures "
                           "simultaneously' % (errors, maxerasures))\n"
                           '            # Return a tuple with the maximum number of simultaneously corrected '
                           'errors and erasures\n'
                           '            return errors, maxerasures\n'
                           '        # Return a tuple with the maximum number of errors and erasures (independently '
                           'corrected)\n'
                           '        if verbose:\n'
                           "            print('This codec can correct up to %i errors and %i erasures "
                           "independently' % (maxerrors, maxerasures))\n"
                           '        return maxerrors, maxerasures\n',
       'service': '"""ZMQ app boundary. All sockets and Engine methods belong to one thread."""\n'
                  'import queue\n'
                  'import threading\n'
                  'import time\n'
                  'import zmq\n'
                  'from .engine import Engine\n'
                  '\n'
                  '\n'
                  'class Service:\n'
                  '    def __init__(self, config, transmit, incoming=None, sensor=None, transport_tick=None):\n'
                  '        self.c=config;self.transmit=transmit;self.incoming=incoming or queue.Queue()\n'
                  '        '
                  'self.sensor=sensor;self.transport_tick=transport_tick;self.stop_event=threading.Event()\n'
                  '        self.ready=threading.Event();self.error=None;self.thread=None\n'
                  '\n'
                  '    def start(self):\n'
                  '        '
                  "self.thread=threading.Thread(target=self.run,name='radio-mac',daemon=True);self.thread.start()\n"
                  "        if not self.ready.wait(5):raise RuntimeError('Radio service did not start')\n"
                  '        if self.error:raise RuntimeError(str(self.error))\n'
                  '\n'
                  '    def stop(self):\n'
                  '        self.stop_event.set()\n'
                  '        if self.thread:self.thread.join(5)\n'
                  '\n'
                  '    def run(self):\n'
                  '        '
                  'context=zmq.Context();commands=context.socket(zmq.PULL);events=context.socket(zmq.PUSH)\n'
                  '        commands.setsockopt(zmq.MAXMSGSIZE,1024*1024)\n'
                  '        for s in (commands,events):s.setsockopt(zmq.LINGER,0)\n'
                  '        engine=None\n'
                  '        try:\n'
                  "            commands.bind('tcp://127.0.0.1:'+str(self.c['commands_port']))\n"
                  "            events.bind('tcp://127.0.0.1:'+str(self.c['events_port']))\n"
                  '            def emit(event):\n'
                  '                try:events.send_json(event,zmq.NOBLOCK)\n'
                  '                except zmq.Again:pass # Durable snapshot recovers message events on reconnect.\n'
                  '            engine=Engine(self.c,self.transmit,emit)\n'
                  '            self.ready.set()\n'
                  '            while not self.stop_event.is_set():\n'
                  '                if self.transport_tick:self.transport_tick(engine)\n'
                  '                if self.sensor:\n'
                  '                    reading=self.sensor()\n'
                  '                    if reading is not None:engine.sense(*reading)\n'
                  '                for _ in range(100):\n'
                  '                    try:engine.receive(self.incoming.get_nowait())\n'
                  '                    except queue.Empty:break\n'
                  '                for _ in range(100):\n'
                  '                    try:cmd=commands.recv_json(zmq.NOBLOCK)\n'
                  '                    except zmq.Again:break\n'
                  '                    try:\n'
                  "                        if cmd.get('cmd')=='send':engine.enqueue(cmd)\n"
                  "                        elif cmd.get('cmd')=='hello':engine.snapshot()\n"
                  "                        elif cmd.get('cmd')=='threshold':\n"
                  "                            value=float(cmd['db'])\n"
                  "                            if not -140<=value<=20:raise ValueError('Threshold outside -140..20 "
                  "dB')\n"
                  "                            engine.c['cs_threshold_db']=value\n"
                  '                    except Exception as exc:\n'
                  '                        '
                  "emit(dict(event='status',id=cmd.get('id'),status='failed',reason=str(exc)))\n"
                  '                engine.tick();self.stop_event.wait(0.003)\n'
                  '        except Exception as exc:\n'
                  "            self.error=exc;self.ready.set();print('Radio service stopped:',exc,flush=True)\n"
                  '        finally:\n'
                  '            if engine:engine.close()\n'
                  '            commands.close();events.close();context.term()\n'}
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'

      class _EmbeddedRadioLoader(_abc.MetaPathFinder, _abc.Loader):
          def find_spec(self, fullname, path=None, target=None):
              prefix = '_pixel_pulse_radio.'
              if fullname.startswith(prefix) and fullname[len(prefix):] in _RADIO_SOURCES:
                  return _util.spec_from_loader(fullname, self)
              return None

          def create_module(self, spec):
              return None

          def exec_module(self, module):
              name = module.__name__.split('.')[-1]
              module.__file__ = '<Pixel Pulse GRC>/' + name + '.py'
              exec(compile(_RADIO_SOURCES[name], module.__file__, 'exec'), module.__dict__)

      if '_pixel_pulse_radio' not in _sys.modules:
          _package = _types.ModuleType('_pixel_pulse_radio')
          _package.__path__ = []
          _package.__package__ = '_pixel_pulse_radio'
          _sys.modules['_pixel_pulse_radio'] = _package
          _sys.meta_path.insert(0, _EmbeddedRadioLoader())

      from _pixel_pulse_radio.config import load
      radio_config = load(os.environ.get("SDRCHAT_CONFIG", "configs/node_a.json"))
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pixel_pulse_attach_radio
  id: snippet
  parameters:
    section: main_after_init
    code: self.epy_mac_bridge.attach_radio(self.iio_pluto_sink_0, self.iio_pluto_source_0)
  states: {}

connections:
- [analog_agc_xx_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_crc_append_0, out, epy_rs_encoder, pdu_in]
- [digital_crc_check_0_0, ok, epy_mac_bridge, rx_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', epy_training_correlator, '0']
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_mac_bridge, tx_out, digital_crc_append_0, in]
- [epy_nlms, '0', digital_costas_loop_cc_0_0, '0']
- [epy_rs_decoder, pdu_out, digital_crc_check_0_0, in]
- [epy_rs_encoder, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_training_correlator, '0', epy_nlms, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', epy_mac_bridge, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_rs_decoder, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
