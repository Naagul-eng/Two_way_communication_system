options:
  parameters:
    author: Pixel_Pulse
    generate_options: qt_gui
    id: Packetized_transmitter_bpsk
    output_language: python
    title: CDP
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1100010111011000111110101000111101100010000001011010011100001101"'
  states: {}
- name: bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1,1] '
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1,]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import secrets
      import struct

      from gnuradio import gr
      import pmt


      TYPE_TEXT = 0x01
      TYPE_IMAGE = 0x02
      TYPE_AUDIO = 0x03

      MAX_PAYLOAD = 200
      MAX_SEGMENTS = 255

      # SRC, DST, TYPE, MESSAGE_ID, SEQ, TOTAL, PAYLOAD_LENGTH
      HEADER_FORMAT = ">BBBIBBH"
      HEADER_LEN = struct.calcsize(HEADER_FORMAT)


      class blk(gr.basic_block):

          def __init__(self, src_addr=0x01, dst_addr=0x03,
                       msg_type=TYPE_TEXT):
              gr.basic_block.__init__(
                  self,
                  name="Packet Builder",
                  in_sig=None,
                  out_sig=None
              )

              self.src_addr = src_addr & 0xFF
              self.dst_addr = dst_addr & 0xFF
              self.msg_type = msg_type & 0xFF

              # Random starting point reduces collisions after restarting TX.
              self._next_message_id = secrets.randbits(32)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(
                  pmt.intern("pdu_in"),
                  self.handle_msg
              )

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  print("[TX] Invalid PDU")
                  return

              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[TX] PDU data is not a u8vector")
                  return

              try:
                  payload = bytes(pmt.u8vector_elements(data))
              except Exception as exc:
                  print("[TX] Could not extract payload:", exc)
                  return

              segments = [
                  payload[offset:offset + MAX_PAYLOAD]
                  for offset in range(0, len(payload), MAX_PAYLOAD)
              ]

              # Preserve support for an empty message.
              if not segments:
                  segments = [b""]

              total = len(segments)

              if total > MAX_SEGMENTS:
                  print(
                      "[TX] Message too large:",
                      len(payload),
                      "bytes; maximum is",
                      MAX_PAYLOAD * MAX_SEGMENTS
                  )
                  return

              message_id = self._next_message_id
              self._next_message_id = (
                  self._next_message_id + 1
              ) & 0xFFFFFFFF

              for seq, segment in enumerate(segments):
                  header = struct.pack(
                      HEADER_FORMAT,
                      self.src_addr,
                      self.dst_addr,
                      self.msg_type,
                      message_id,
                      seq,
                      total,
                      len(segment)
                  )

                  packet = header + segment

                  output_vector = pmt.init_u8vector(
                      len(packet),
                      list(packet)
                  )

                  self.message_port_pub(
                      pmt.intern("pdu_out"),
                      pmt.cons(meta, output_vector)
                  )

              print(
                  "[TX] Message ID",
                  message_id,
                  "sent as",
                  total,
                  "segment(s)"
              )
    dst_addr: '3'
    msg_type: '1'
    src_addr: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Message to PDU",
                  in_sig=None,
                  out_sig=None
              )

              # Input from QT GUI Message Edit Box
              self.message_port_register_in(
                  pmt.intern("msg_in")
              )

              # Output to your Packet Builder
              self.message_port_register_out(
                  pmt.intern("pdu_out")
              )

              self.set_msg_handler(
                  pmt.intern("msg_in"),
                  self.handle_message
              )


          def handle_message(self, msg):

              try:
                  # QT Message Edit Box normally sends PMT string
                  if pmt.is_symbol(msg):
                      text = pmt.symbol_to_string(msg)

                  elif pmt.is_pair(msg):
                      value = pmt.cdr(msg)

                      if pmt.is_symbol(value):
                          text = pmt.symbol_to_string(value)
                      else:
                          text = str(pmt.to_python(value))

                  else:
                      text = str(pmt.to_python(msg))

              except Exception as e:
                  print("[TX] Could not read message:", e)
                  return


              # Ignore empty messages
              if not text.strip():
                  print("[TX] Empty message ignored")
                  return


              # Convert text to UTF-8 bytes
              payload = text.encode("utf-8")


              # Make u8 vector
              vector = pmt.init_u8vector(
                  len(payload),
                  list(payload)
              )


              # Make standard PDU
              pdu = pmt.cons(
                  pmt.PMT_NIL,
                  vector
              )


              # Send exactly once
              self.message_port_pub(
                  pmt.intern("pdu_out"),
                  pdu
              )


              print("[TX] Sending:", text)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: BPSK Acquisition Preamble

      Prepends a deterministic acquisition preamble to every packet.

      Preamble structure:
          1. Repeating 0x55 bytes for AGC and timing acquisition.
          2. Deterministic pseudo-random bytes for carrier-loop and
             equalizer convergence.
          3. The original packet, beginning with its access code.

      The receiver does not need to remove the preamble. Its access-code
      correlator detects the beginning of the actual packet.
      """

      import numpy as np

      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):

          def __init__(self, num_dummy_bytes=512):
              gr.basic_block.__init__(
                  self,
                  name="PDU Prepend BPSK Acquisition Preamble",
                  in_sig=None,
                  out_sig=None
              )

              self.num_dummy_bytes = max(
                  0,
                  int(num_dummy_bytes)
              )

              # Create the preamble once so every packet uses the same
              # deterministic sequence.
              self.preamble = self._create_preamble(
                  self.num_dummy_bytes
              )

              self.message_port_register_in(
                  pmt.intern("pdu_in")
              )

              self.message_port_register_out(
                  pmt.intern("pdu_out")
              )

              self.set_msg_handler(
                  pmt.intern("pdu_in"),
                  self.handle_msg
              )

              print(
                  "[TX] BPSK preamble configured:",
                  self.num_dummy_bytes,
                  "bytes"
              )

          def _create_preamble(self, total_length):
              """
              Create a deterministic two-part preamble.

              The first section uses 0x55 for regular transitions.
              The remaining section uses deterministic pseudo-random
              bytes to provide a broadband BPSK training signal.
              """

              if total_length <= 0:
                  return np.empty(
                      0,
                      dtype=np.uint8
                  )

              # Use up to 64 bytes of alternating 01010101 bits.
              alternating_length = min(
                  64,
                  total_length
              )

              alternating_data = np.full(
                  alternating_length,
                  0x55,
                  dtype=np.uint8
              )

              pn_length = total_length - alternating_length

              if pn_length <= 0:
                  return alternating_data

              # A fixed seed ensures that the same pseudo-random
              # sequence is produced each time the flowgraph starts.
              rng = np.random.default_rng(
                  seed=0xB5A1
              )

              pn_data = rng.integers(
                  low=0,
                  high=256,
                  size=pn_length,
                  dtype=np.uint8
              )

              return np.concatenate(
                  (
                      alternating_data,
                      pn_data
                  )
              )

          def handle_msg(self, msg):
              """
              Validate the input PDU, prepend the acquisition preamble,
              and publish the resulting PDU.
              """

              if not pmt.is_pair(msg):
                  print("[TX] Preamble block received an invalid PDU")
                  return

              metadata = pmt.car(msg)
              data_pmt = pmt.cdr(msg)

              if not pmt.is_u8vector(data_pmt):
                  print(
                      "[TX] Preamble block expected a u8vector"
                  )
                  return

              try:
                  packet_data = np.asarray(
                      pmt.u8vector_elements(data_pmt),
                      dtype=np.uint8
                  )

              except Exception as exc:
                  print(
                      "[TX] Could not extract packet data:",
                      exc
                  )
                  return

              output_data = np.concatenate(
                  (
                      self.preamble,
                      packet_data
                  )
              )

              output_vector = pmt.init_u8vector(
                  len(output_data),
                  output_data.tolist()
              )

              output_pdu = pmt.cons(
                  metadata,
                  output_vector
              )

              self.message_port_pub(
                  pmt.intern("pdu_out"),
                  output_pdu
              )

              print(
                  "[TX] Added",
                  len(self.preamble),
                  "preamble bytes; packet:",
                  len(packet_data),
                  "bytes; total:",
                  len(output_data),
                  "bytes"
              )
    num_dummy_bytes: '512'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: '''ip:192.168.1.10'''
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,2
    is_pair: 'False'
    label: Message
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX Baseband Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After Multiplication (0.8)"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"TX - After RRC pulse shaping"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [epy_block_0, pdu_out, digital_crc_append_0, in]
- [epy_block_1, pdu_out, epy_block_0, pdu_in]
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [qtgui_edit_box_msg_0, msg, epy_block_1, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
