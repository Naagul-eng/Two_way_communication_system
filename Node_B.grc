options:
  parameters:
    author: naagul
    description: Initial host-timed CSMA experiment; calibrate CCA and verify TX idle behavior.
    generate_options: qt_gui
    id: node_b_csma_starter
    output_language: python
    title: Node B — CSMA starter
  states: {}

blocks:
- name: LMS_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '0.02'
    type: lms
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '40000'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '40000'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: commands_address
  id: variable
  parameters:
    value: '''tcp://127.0.0.1:5556'''
  states: {}
- name: correlation_symbols
  id: variable
  parameters:
    value: training_symbols[:64]
  states: {}
- name: cs_threshold_db
  id: variable
  parameters:
    comment: EXAMPLE absolute 10*log10(mean |IQ|^2); calibrate on your radio, not dBm.
    value: '-40.0'
  states: {}
- name: cw_max
  id: variable
  parameters:
    value: '128'
  states: {}
- name: cw_min
  id: variable
  parameters:
    value: '8'
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: difs
  id: variable
  parameters:
    value: '0.010'
  states: {}
- name: events_address
  id: variable
  parameters:
    value: '''tcp://127.0.0.1:5555'''
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freqency
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: peer_addr
  id: variable
  parameters:
    value: '''A1'''
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: receive_dir
  id: variable
  parameters:
    value: '''./received_B1'''
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: RX matched filter uses the same roll-off as the QPSK transmitter.
    value: filter.firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: shared_key
  id: variable
  parameters:
    value: b'u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P='
  states: {}
- name: slot_time
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: training_symbols
  id: variable
  parameters:
    comment: Embedded copy of the 512 QPSK training symbols (no external module needed).
    value: '[0.7071068286895752*complex(1-2*(int(c)&1), 1-2*(int(c)>>1)) for c in "13112032313003230122132103232302310031210210303331101200130211012123020131100222102133031021330030311320232330111310323223123100123330121323201201331303233201113222213311010310213322303002020113322203321033203301232000023130213312222030312223031133230032123210232303332023213001222313033210303222303132030320013112023103122103020200003201233102301103320312002020202023303101222010133120313121200301102033031203031320121223232223031103130110231010111303020220303030130031203303233110330222030001011210033003213230"]'
  states: {}
- name: ack_timeout
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import json
      import math

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      KINDS = ('text', 'image', 'audio')


      def profile(text, image, audio, low, high, integer=False):
          values = [int(v) if integer else float(v) for v in (text, image, audio)]
          if any(not math.isfinite(v) or not low <= v <= high for v in values):
              raise ValueError('Profile values must be in %s..%s' % (low, high))
          return dict(zip(KINDS, values))


      class TimeoutPolicy:
          """RFC 6298-style estimator, with application-specific bounds (not TCP)."""
          def __init__(self, initial, floors, maximum=30.0):
              self.initial, self.floors, self.maximum = initial, floors, maximum
              if any(floors[k] > initial[k] for k in KINDS):
                  raise ValueError('RTO floor must not exceed its initial value')
              self.estimates = {}

          def observe(self, kind, sample):
              sample = float(sample)
              if kind not in self.initial or not math.isfinite(sample) or sample <= 0:
                  raise ValueError('Invalid RTT observation')
              if kind not in self.estimates:
                  srtt, variation = sample, sample / 2.0
              else:
                  srtt, variation = self.estimates[kind]
                  variation = 0.75 * variation + 0.25 * abs(srtt - sample)
                  srtt = 0.875 * srtt + 0.125 * sample
              self.estimates[kind] = srtt, variation
              return self.timeout(kind)

          def timeout(self, kind):
              if kind not in self.estimates:
                  return self.initial[kind]
              srtt, variation = self.estimates[kind]
              return min(self.maximum, max(self.floors[kind], srtt + max(0.01, 4 * variation)))


      class blk(gr.basic_block):
          def __init__(self, text_initial=1.0, image_initial=2.0, audio_initial=3.0,
                       text_min=0.5, image_min=1.0, audio_min=1.5):
              gr.basic_block.__init__(self, name='Adaptive ACK Timeout Selection', in_sig=None, out_sig=None)
              self.policy = TimeoutPolicy(profile(text_initial, image_initial, audio_initial, 0.05, 30),
                                          profile(text_min, image_min, audio_min, 0.05, 30))
              for port in ('in', 'rtt'):
                  self.message_port_register_in(pmt.intern(port))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle)
              self.set_msg_handler(pmt.intern('rtt'), self.observe)

          def handle(self, msg):
              command = decode(msg)
              if command.get('op') == 'send':
                  kind = command['kind']
                  command.update(ack_timeout=self.policy.timeout(kind), rto_floor=self.policy.floors[kind])
              self.message_port_pub(pmt.intern('out'), control(command))

          def observe(self, msg):
              sample = decode(msg)
              timeout = self.policy.observe(sample['kind'], sample['seconds'])
              self.message_port_pub(pmt.intern('out'), control(dict(
                  op='rto_update', kind=sample['kind'], seconds=timeout)))
    audio_initial: '2.0'
    audio_min: '2.0'
    image_initial: '2.0'
    image_min: '2.0'
    text_initial: '2.0'
    text_min: '2.0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '240'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '240'
    max_iter: '4000'
    scale: 1.0/240.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: carrier_sense
  id: epy_block
  parameters:
    _source_code: |
      """Paste into a GRC Embedded Python Block; float input is averaged |IQ|**2."""
      from gnuradio import gr
      import numpy as np
      import pmt
      import json
      import time
      import math


      class blk(gr.sync_block):
          def __init__(self, threshold_db=-40.0, hysteresis_db=3.0,
                       report_period=0.005):
              gr.sync_block.__init__(self, name='Carrier Sense',
                                     in_sig=[np.float32], out_sig=None)
              if not math.isfinite(threshold_db) or hysteresis_db < 0 or report_period <= 0:
                  raise ValueError('Invalid carrier-sense settings')
              self.high = 10.0 ** (threshold_db / 10.0)
              self.low = 10.0 ** ((threshold_db - hysteresis_db) / 10.0)
              self.period = float(report_period)
              self.busy = True
              self.last = 0.0
              self.message_port_register_out(pmt.intern('cca'))

          def work(self, input_items, output_items):
              samples = input_items[0]
              if not len(samples):
                  return 0
              # Conservatively retain even a short busy interval in this work batch.
              peak = float(np.max(samples))
              before = self.busy
              if not math.isfinite(peak) or peak < 0:
                  self.busy = True
              elif peak >= self.high:
                  self.busy = True
              elif peak < self.low:
                  self.busy = False
              now = time.monotonic()
              if before != self.busy or now - self.last >= self.period:
                  self.last = now
                  message = dict(busy=self.busy, observed=now,
                                 power_db=10.0 * math.log10(max(peak, 1e-30))
                                 if math.isfinite(peak) else None)
                  self.message_port_pub(pmt.intern('cca'),
                                        pmt.intern(json.dumps(message)))
              return len(samples)
    comment: Calibrate the absolute threshold before RF testing.
    hysteresis_db: '3.0'
    report_period: '0.005'
    threshold_db: cs_threshold_db
  states: {}
- name: corr_est
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: '1'
    symbols: correlation_symbols
    threshold: '0.65'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: decoded_bits_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    minoutbuf: '131072'
    tag: decoded_bits
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: LMS_alg
    num_taps: '7'
    sps: '1'
    training_sequence: training_symbols
    training_start_tag: '''corr_est'''
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    constellation: digital.constellation_qpsk().base()
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import json
      import hashlib
      import struct
      import numpy as np

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      ACQUISITION = hashlib.shake_256(b'Duplex-QPSK-acquisition-v2').digest(768)
      TRAINING = hashlib.shake_256(b'Duplex-QPSK-START-v1').digest(128)
      SYNC = bytes.fromhex('d391c5a76e2b408f')
      SYNC_BITS = np.unpackbits(np.frombuffer(SYNC, dtype=np.uint8))
      TAIL = hashlib.shake_256(b'Duplex-QPSK-tail-v2').digest(512)
      MAX_HDLC_BITS = 40000
      MAX_CODE_BITS = 2 * (MAX_HDLC_BITS + 6)




      def waveform_bytes(encoded_bits):
          bits = (np.frombuffer(encoded_bits, dtype=np.uint8)
                  if isinstance(encoded_bits, bytes) else np.asarray(encoded_bits, dtype=np.uint8))
          if not 12 < len(bits) <= MAX_CODE_BITS or len(bits) % 2 or np.any(bits > 1):
              raise ValueError('Invalid terminated FEC bit count')
          header = struct.pack('!II', len(bits), len(bits) ^ 0xffffffff)
          return ACQUISITION + TRAINING + SYNC + header * 3 + np.packbits(bits).tobytes() + TAIL




      class BurstTX(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name='Known Preamble + FEC Burst', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle)

          def handle(self, msg):
              self.message_port_pub(pmt.intern('pdu_out'), pdu(waveform_bytes(raw_pdu(msg))))




      class blk(BurstTX):
          def __init__(self):
              super().__init__()
  states: {}
- name: fec_burst_rx
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import hashlib
      import struct
      import numpy as np

      ACQUISITION = hashlib.shake_256(b'Duplex-QPSK-acquisition-v2').digest(768)
      TRAINING = hashlib.shake_256(b'Duplex-QPSK-START-v1').digest(128)
      SYNC = bytes.fromhex('d391c5a76e2b408f')
      SYNC_BITS = np.unpackbits(np.frombuffer(SYNC, dtype=np.uint8))
      TAIL = hashlib.shake_256(b'Duplex-QPSK-tail-v2').digest(512)
      MAX_HDLC_BITS = 40000
      MAX_CODE_BITS = 2 * (MAX_HDLC_BITS + 6)




      class BurstRX(gr.sync_block):
          """Recover codeword boundaries from hard bits, then emit native FEC metrics.

          Search is vectorized rather than a per-bit Python callback. Corrupt length
          headers are rejected; storage is bounded by one maximum codeword. Header
          redundancy is separate from the convolutionally protected HDLC frame.
          """
          def __init__(self, sync_errors=3):
              gr.sync_block.__init__(self, name='FEC Burst Acquisition', in_sig=[np.uint8], out_sig=None)
              self.sync_errors = int(sync_errors)
              self.buf = np.empty(0, dtype=np.uint8)
              self.message_port_register_out(pmt.intern('out'))
              self.accepted = self.bad_headers = 0

          def work(self, input_items, output_items):
              incoming = input_items[0]
              self.buf = np.concatenate((self.buf, incoming & 1))
              while len(self.buf) >= 64:
                  # Candidate sync, with <=3 errors. Retain candidate until complete.
                  windows = np.lib.stride_tricks.sliding_window_view(self.buf, 64)
                  # XOR avoids signed integer overflow in dot-product correlation.
                  candidates = np.flatnonzero(np.count_nonzero(windows != SYNC_BITS, axis=1) <= self.sync_errors)
                  if not len(candidates):
                      self.buf = self.buf[-63:].copy()
                      break
                  pos = int(candidates[0])
                  if pos:
                      self.buf = self.buf[pos:].copy()
                  if len(self.buf) < 64 + 192:
                      break
                  copies = self.buf[64:256].reshape(3, 64)
                  header = np.packbits(np.sum(copies, axis=0) >= 2).tobytes()
                  length, inverse = struct.unpack('!II', header)
                  if length ^ inverse != 0xffffffff or not 12 < length <= MAX_CODE_BITS or length % 2:
                      self.bad_headers += 1
                      self.buf = self.buf[1:]
                      continue
                  if len(self.buf) < 256 + length:
                      break
                  metrics = self.buf[256:256 + length].astype(np.float32) * 2 - 1
                  self.message_port_pub(pmt.intern('out'), pmt.cons(pmt.PMT_NIL,
                      pmt.init_f32vector(len(metrics), metrics)))
                  self.accepted += 1
                  self.buf = self.buf[256 + length:].copy()
              return len(incoming)




      class blk(BurstRX):
          def __init__(self, sync_errors=3):
              super().__init__(sync_errors)
    sync_errors: '3'
  states: {}
- name: fec_decoder
  id: fec_async_decoder
  parameters:
    decoder: cc_decoder
    mtu: '5000'
  states: {}
- name: fec_encoder
  id: fec_async_encoder
  parameters:
    encoder: cc_encoder
    mtu: '5000'
  states: {}
- name: gui_commands
  id: zeromq_pull_msg_source
  parameters:
    address: commands_address
    bind: 'True'
    timeout: '10'
  states: {}
- name: gui_events
  id: zeromq_push_msg_sink
  parameters:
    address: events_address
    timeout: '10'
  states: {}
- name: hdlc_flush
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import json
      import hashlib
      import struct
      import numpy as np

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      ACQUISITION = hashlib.shake_256(b'Duplex-QPSK-acquisition-v2').digest(768)
      TRAINING = hashlib.shake_256(b'Duplex-QPSK-START-v1').digest(128)
      SYNC = bytes.fromhex('d391c5a76e2b408f')
      SYNC_BITS = np.unpackbits(np.frombuffer(SYNC, dtype=np.uint8))
      TAIL = hashlib.shake_256(b'Duplex-QPSK-tail-v2').digest(512)
      MAX_HDLC_BITS = 40000
      MAX_CODE_BITS = 2 * (MAX_HDLC_BITS + 6)




      class HDLCFlush(gr.basic_block):
          """Flush native deframer scheduler locally; these zeros never go on air."""
          def __init__(self):
              gr.basic_block.__init__(self, name='Decoded Bits + Local Flush', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle)

          def handle(self, msg):
              bits = raw_pdu(msg)
              if len(bits) <= MAX_HDLC_BITS:
                  self.message_port_pub(pmt.intern('out'), pdu(bits + bytes(8192)))


      class blk(HDLCFlush):
          def __init__(self):
              super().__init__()
  states: {}
- name: hdlc_rx
  id: digital_hdlc_deframer_bp
  parameters:
    max: '4096'
    min: '2'
  states: {}
- name: hdlc_tx
  id: digital_hdlc_framer_pb
  parameters:
    comment: Reserve a whole worst-case stuffed 4092-byte PDU (over 39k unpacked bits). Framing and FCS unchanged.
    frame_tag_name: packet_len
    minoutbuf: '131072'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2400000'
    buffer_size: buffer_size
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freqency
    samplerate: samp_rate
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2400000'
    bbdc: 'True'
    buffer_size: buffer_size
    filter_source: '''Auto'''
    frequency: freqency
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: payload_size
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import json
      import math

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      KINDS = ('text', 'image', 'audio')


      def profile(text, image, audio, low, high, integer=False):
          values = [int(v) if integer else float(v) for v in (text, image, audio)]
          if any(not math.isfinite(v) or not low <= v <= high for v in values):
              raise ValueError('Profile values must be in %s..%s' % (low, high))
          return dict(zip(KINDS, values))


      class TimeoutPolicy:
          """RFC 6298-style estimator, with application-specific bounds (not TCP)."""
          def __init__(self, initial, floors, maximum=30.0):
              self.initial, self.floors, self.maximum = initial, floors, maximum
              if any(floors[k] > initial[k] for k in KINDS):
                  raise ValueError('RTO floor must not exceed its initial value')
              self.estimates = {}

          def observe(self, kind, sample):
              sample = float(sample)
              if kind not in self.initial or not math.isfinite(sample) or sample <= 0:
                  raise ValueError('Invalid RTT observation')
              if kind not in self.estimates:
                  srtt, variation = sample, sample / 2.0
              else:
                  srtt, variation = self.estimates[kind]
                  variation = 0.75 * variation + 0.25 * abs(srtt - sample)
                  srtt = 0.875 * srtt + 0.125 * sample
              self.estimates[kind] = srtt, variation
              return self.timeout(kind)

          def timeout(self, kind):
              if kind not in self.estimates:
                  return self.initial[kind]
              srtt, variation = self.estimates[kind]
              return min(self.maximum, max(self.floors[kind], srtt + max(0.01, 4 * variation)))


      class blk(gr.basic_block):
          def __init__(self, text_bytes=256, image_bytes=512, audio_bytes=512):
              gr.basic_block.__init__(self, name='Payload Size Selection', in_sig=None, out_sig=None)
              self.sizes = profile(text_bytes, image_bytes, audio_bytes, 128, 1024, True)
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle)

          def handle(self, msg):
              command = decode(msg)
              if command.get('op') == 'send':
                  command['chunk_size'] = self.sizes[command['kind']]
              self.message_port_pub(pmt.intern('out'), control(command))
    audio_bytes: '512'
    image_bytes: '512'
    text_bytes: '256'
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Received Contellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After syncronization"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freqency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freqency
    fftsize: '1024'
    name: '"Before AGC"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Before AGC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sr_arq
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import queue
      import re
      import secrets
      import threading
      import time
      from collections import OrderedDict
      from pathlib import Path
      from gnuradio import gr
      import pmt
      import hashlib
      import struct
      import numpy as np
      import tempfile
      from cryptography.fernet import Fernet, InvalidToken

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      ACQUISITION = hashlib.shake_256(b'Duplex-QPSK-acquisition-v2').digest(768)
      TRAINING = hashlib.shake_256(b'Duplex-QPSK-START-v1').digest(128)
      SYNC = bytes.fromhex('d391c5a76e2b408f')
      SYNC_BITS = np.unpackbits(np.frombuffer(SYNC, dtype=np.uint8))
      TAIL = hashlib.shake_256(b'Duplex-QPSK-tail-v2').digest(512)
      MAX_HDLC_BITS = 40000
      MAX_CODE_BITS = 2 * (MAX_HDLC_BITS + 6)




      def airtime_bound(pdu_bytes, sample_rate=2400000, sps=4):
          # Worst-case stuffing, two flags, FCS, six CC termination bits and byte pad.
          hdlc_bits = 16 + ((pdu_bytes + 2) * 8 * 6 + 4) // 5
          coded_bytes = (2 * (hdlc_bits + 6) + 7) // 8
          burst_bytes = len(ACQUISITION) + len(TRAINING) + 32 + coded_bytes + len(TAIL)
          return burst_bytes * 8 / (2 * sample_rate / sps)




      _META, _DATA, _END, _ACK, _ERROR, _CANCEL = range(1, 7)
      _HEADER = struct.Struct('!4sB2s2s16sI')
      _MAGIC = b'NGH3'


      class ChannelAccess:
          """Soft-timed CSMA: all frames contend, replies have queue priority.

          cw is a count of slots; random choice is 0..cw-1. Busy freezes the
          remaining count; each return to idle requires another complete DIFS.
          """
          def __init__(self, difs=0.010, slot_time=0.005, cw_min=8, cw_max=128,
                       cca_timeout=0.100, tx_guard=0.020, clock=time.monotonic):
              if not (0 < slot_time <= difs and 1 <= cw_min <= cw_max
                      and cca_timeout > difs and tx_guard >= 0):
                  raise ValueError('Invalid CSMA timing/window parameters')
              self.difs, self.slot = float(difs), float(slot_time)
              self.cw_min, self.cw_max = int(cw_min), int(cw_max)
              self.timeout, self.guard, self.clock = cca_timeout, tx_guard, clock
              self.lock = threading.Lock()
              self.last = None
              self.busy = True
              self.idle_since = None
              self.token = None
              self.remaining = None
              self.slot_at = None
              self.until = 0.0

          def observe(self, busy, observed):
              now = self.clock()
              with self.lock:
                  if (not isinstance(busy, bool) or not np.isfinite(observed)
                          or observed > now or now - observed > self.timeout):
                      self.busy, self.idle_since, self.slot_at = True, None, None
                      return
                  if self.last is not None and observed < self.last:
                      return
                  gap = self.last is None or observed - self.last > self.timeout
                  if busy:
                      self.idle_since = self.slot_at = None
                  elif self.busy or gap or self.idle_since is None:
                      self.idle_since = now
                      self.slot_at = None
                  self.busy, self.last = busy, observed

          def grant(self, token, retry=0):
              now = self.clock()
              with self.lock:
                  if token != self.token:
                      self.token = token
                      cw = min(self.cw_max, self.cw_min * (2 ** min(retry, 20)))
                      self.remaining = secrets.randbelow(cw)
                      self.slot_at = None
                  if (self.last is None or now - self.last > self.timeout or self.busy):
                      self.idle_since = self.slot_at = None
                      return False
                  if now < self.until:
                      self.slot_at = None
                      return False
                  if self.idle_since is None:
                      self.idle_since = now
                  ready = max(self.idle_since, self.until) + self.difs
                  if now < ready:
                      return False
                  if self.slot_at is None:
                      self.slot_at = now
                  # No catch-up after host scheduling stalls: this is conservative.
                  if self.remaining and now - self.slot_at >= self.slot:
                      self.remaining -= 1
                      self.slot_at = now
                  return self.remaining == 0

          def reserve(self, seconds):
              with self.lock:
                  self.until = self.clock() + seconds + self.guard
                  self.token = self.remaining = self.slot_at = None
                  self.idle_since = None


      class TransferCore:
          """Selective Repeat, independently in each direction (one file per direction).

          META (0) is acknowledged before DATA (1..N). DATA uses a bounded sliding
          window and individual ACKs/timers. END (N+1) is sent after all DATA ACKs,
          and acknowledged only after SHA-256 verification and saving the file.
          32-bit sequence numbers never wrap within a transfer. A random 128-bit
          transfer ID separates transfers. All methods run on one worker thread.
          """
          def __init__(self, my_addr, peer_addr, shared_key, receive_dir, emit, event,
                       chunk_size=512, ack_timeout=1.0, max_retries=8,
                       max_file_mb=16, window_size=4, packet_interval=0.02,
                       clock=time.monotonic):
              for addr in (my_addr, peer_addr):
                  if not isinstance(addr, str) or len(addr.encode('ascii')) != 2:
                      raise ValueError('Addresses must be exactly two ASCII characters')
              if my_addr == peer_addr:
                  raise ValueError('Local and peer addresses must differ')
              if not 128 <= int(chunk_size) <= 1024:
                  raise ValueError('chunk_size must be 128..1024 bytes')
              if not 0.05 <= float(ack_timeout) <= 30 or not 0 <= int(max_retries) <= 20:
                  raise ValueError('ack_timeout: 0.05..30 seconds; max_retries: 0..20')
              if not 1 <= int(max_file_mb) <= 256:
                  raise ValueError('max_file_mb must be 1..256')
              if not 1 <= int(window_size) <= 64:
                  raise ValueError('window_size must be 1..64 packets')
              if not 0 <= float(packet_interval) <= 5:
                  raise ValueError('packet_interval must be 0..5 seconds')
              key = shared_key.encode('ascii') if isinstance(shared_key, str) else shared_key
              self.cipher = Fernet(key)
              self.me, self.peer = my_addr.encode('ascii'), peer_addr.encode('ascii')
              self.directory = Path(receive_dir).expanduser().resolve()
              self.emit, self.event, self.clock = emit, event, clock
              self.chunk, self.window = int(chunk_size), int(window_size)
              self.rtt_event = lambda kind, sample: None
              self.rtos = {}
              self.rto_floor = 0.5
              self.timeout, self.retries = float(ack_timeout), int(max_retries)
              self.interval = float(packet_interval)
              self.limit = int(max_file_mb) * 1024 * 1024
              # Allow a complete retry round even when 64 packets are heavily paced.
              self.idle_timeout = max(120, 4 * (self.retries + 1) *
                                      (30.0 + 64 * self.interval))
              self.receipt_ttl = max(1800, self.idle_timeout * 2)
              self.tx = self.rx = None
              self.next_emit = 0.0
              self.receipts = OrderedDict()
              self.access = ChannelAccess(clock=clock)
              self.replies = OrderedDict()

          def _event(self, direction, state, transfer=None, **extra):
              t = transfer or {}
              self.event(dict(direction=direction, state=state, name=t.get('name', ''),
                              kind=t.get('kind', ''), total=t.get('size', 0),
                              done=t.get('done', 0), started=t.get('started', self.clock()),
                              **extra))

          def _wire(self, typ, tid, seq, body=b''):
              plaintext = _HEADER.pack(_MAGIC, typ, self.me, self.peer, tid, seq) + body
              frame = self.me + self.peer + self.cipher.encrypt(plaintext)
              if len(frame) > 4092:
                  raise ValueError('Encrypted frame exceeds 4092-byte PDU budget')
              return frame

          def _reply(self, typ, tid, seq, body=b''):
              # Coalesce duplicate replies. All frames obey carrier sense.
              key = (typ, tid, seq, body)
              if key not in self.replies:
                  if len(self.replies) >= 256:
                      self.replies.popitem(last=False)
                  self.replies[key] = self._wire(typ, tid, seq, body)

          @staticmethod
          def _safe_name(name):
              name = str(name).replace('\\', '/').split('/')[-1]
              name = re.sub(r'[^\w. -]', '_', name, flags=re.UNICODE).strip('. ')[:100]
              return name or 'received.bin'

          def send(self, kind, value, chunk_size=None, window_size=None, ack_timeout=None, rto_floor=None):
              if self.tx is not None:
                  raise ValueError('A transfer is already active')
              # Freeze payload and receive-window agreement for this transfer.
              chunk = self.chunk if chunk_size is None else int(chunk_size)
              window = self.window if window_size is None else int(window_size)
              timeout = self.timeout if ack_timeout is None else float(ack_timeout)
              floor = self.rto_floor if rto_floor is None else float(rto_floor)
              if not 128 <= chunk <= 1024 or not 1 <= window <= 64:
                  raise ValueError('Invalid payload size or window')
              if not 0.05 <= floor <= timeout <= 30:
                  raise ValueError('Invalid ACK timeout policy')
              self.chunk, self.window, self.timeout, self.rto_floor = chunk, window, timeout, floor
              self.rtos[kind] = timeout
              if kind == 'text':
                  data, name = value.encode('utf-8'), 'message.txt'
                  if not data or len(data) > 65536:
                      raise ValueError('Type a message of 1..65536 UTF-8 bytes')
              elif kind in ('image', 'audio'):
                  path = Path(value)
                  if not path.is_file() or path.stat().st_size > self.limit:
                      raise ValueError('Choose a file within the configured size limit')
                  with path.open('rb') as f:
                      data = f.read(self.limit + 1)
                  name = path.name
              else:
                  raise ValueError('Unsupported transfer type')
              if len(data) > self.limit:
                  raise ValueError('File exceeds the configured size limit')
              self.tx = dict(tid=secrets.token_bytes(16), data=data, kind=kind,
                             name=self._safe_name(name), size=len(data), done=0,
                             started=self.clock(), n=(len(data) + self.chunk - 1) // self.chunk,
                             digest=hashlib.sha256(data).hexdigest(), phase='meta',
                             base=1, next=1, acked=set(), pending={})
              t = self.tx
              meta = dict(kind=t['kind'], name=t['name'], size=t['size'], chunk=self.chunk,
                          window=self.window, sha256=t['digest'])
              self._queue_packet(_META, 0, json.dumps(meta, ensure_ascii=True,
                                 separators=(',', ':')).encode())
              self._event('tx', 'Sending metadata', t)
              self._pump()

          def _queue_packet(self, typ, seq, body):
              t = self.tx
              t['pending'][seq] = dict(wire=self._wire(typ, t['tid'], seq, body),
                                       sent=None, retry=0, rto=self.timeout)

          def _fill_window(self):
              t = self.tx
              if t['phase'] != 'data':
                  return
              # The window is anchored at the oldest unacknowledged sequence number,
              # not merely at the number of pending packets. This bounds RX buffering.
              while t['next'] <= t['n'] and t['next'] < t['base'] + self.window:
                  seq = t['next']
                  self._queue_packet(_DATA, seq,
                                     t['data'][(seq - 1) * self.chunk:seq * self.chunk])
                  t['next'] += 1
              if t['base'] > t['n']:
                  t['phase'] = 'end'
                  self._queue_packet(_END, t['n'] + 1, bytes.fromhex(t['digest']))
                  self._event('tx', 'Waiting for file verification', t)

          def _acknowledge(self, tid, seq, body):
              t = self.tx
              if body or t is None or t['tid'] != tid:
                  return
              packet = t['pending'].get(seq)
              if packet is None or packet['sent'] is None:
                  return  # Duplicate/stale ACK, or a sequence not yet transmitted.
              # Karn: retransmitted packets cannot provide unambiguous RTT samples.
              if packet['retry'] == 0:
                  self.rtt_event(t['kind'], max(0.001, self.clock() - packet['sent']))
              del t['pending'][seq]
              if t['phase'] == 'meta':
                  t['phase'] = 'data'
              elif t['phase'] == 'end':
                  self._event('tx', 'Complete — receiver verified', t)
                  self.tx = None
                  return
              else:
                  t['done'] += min(self.chunk, t['size'] - (seq - 1) * self.chunk)
                  t['acked'].add(seq)
                  while t['base'] in t['acked']:
                      t['acked'].remove(t['base'])
                      t['base'] += 1
                  self._event('tx', 'Sending', t)
              self._fill_window()
              self._pump()

          def _pump(self):
              """Emit at most one DATA/META/END PDU per call, with retry priority."""
              t, now = self.tx, self.clock()
              if now < self.next_emit:
                  return
              if self.replies:
                  key, wire = next(iter(self.replies.items()))
                  if self.access.grant(('reply', key)):
                      del self.replies[key]
                      duration = max(self.interval, 1.15 * airtime_bound(len(wire)))
                      self.access.reserve(duration)
                      self.next_emit = now + duration
                      self.emit(wire)
                  return
              if t is None:
                  return
              expired = [(p['sent'], seq) for seq, p in t['pending'].items()
                         if p['sent'] is not None and now - p['sent'] >= p['rto']]
              if expired:
                  _, seq = min(expired)
                  p = t['pending'][seq]
                  if p['retry'] >= self.retries:
                      self._abort_tx('Unconfirmed — ACK timeout for packet %d' % seq)
                      return
                  if not self.access.grant((t['tid'], seq, p['retry'] + 1), p['retry'] + 1):
                      return
                  p['retry'] += 1
                  self._event('tx', 'Retry packet %d (%d/%d)' %
                              (seq, p['retry'], self.retries), t)
              else:
                  seq = next((s for s, p in t['pending'].items() if p['sent'] is None), None)
                  if seq is None:
                      return
                  p = t['pending'][seq]
                  if not self.access.grant((t['tid'], seq, 0)):
                      return
              if p['retry']:
                  p['rto'] = min(30.0, 2.0 * p['rto'])
              else:
                  p['rto'] = max(self.rto_floor, self.rtos.get(t['kind'], self.timeout))
                  if t['phase'] == 'end':
                      p['rto'] = max(2.0, p['rto'])  # File hash and fsync allowance.
              p['sent'] = now  # Timestamp PDU submission, not an RF hardware timestamp.
              self.next_emit = now + max(self.interval, 1.15 * airtime_bound(len(p['wire'])))
              self.access.reserve(self.next_emit - now)
              self.emit(p['wire'])

          def receive(self, frame):
              # The upstream HDLC deframer drops bad FCS and removes framing/FCS.
              if len(frame) < 5 or len(frame) > 4092 or frame[:4] != self.peer + self.me:
                  return
              try:
                  raw = self.cipher.decrypt(frame[4:])
                  if len(raw) < _HEADER.size:
                      return
                  magic, typ, src, dst, tid, seq = _HEADER.unpack(raw[:_HEADER.size])
                  if magic != _MAGIC or src != self.peer or dst != self.me:
                      return
                  body = raw[_HEADER.size:]
              except (InvalidToken, ValueError, struct.error):
                  return
              if typ == _ACK:
                  self._acknowledge(tid, seq, body)
              elif typ == _ERROR:
                  if self.tx and tid == self.tx['tid'] and seq in self.tx['pending']:
                      self._abort_tx('Failed: ' + body.decode('utf-8', 'replace')[:180])
              elif typ == _CANCEL:
                  if body:
                      return
                  if self.rx and self.rx['tid'] == tid:
                      self._drop_rx('Cancelled by sender')
                  elif tid not in self.receipts:
                      # A reordered CANCEL can arrive before its META.
                      self._remember(tid, error='Cancelled by sender')
              elif typ in (_META, _DATA, _END):
                  try:
                      self._receive_data(typ, tid, seq, body)
                  except (ValueError, OSError, UnicodeError, KeyError, TypeError) as exc:
                      reason = str(exc)[:180]
                      if self.rx and self.rx['tid'] == tid:
                          self._drop_rx('Failed: ' + reason)
                      elif tid not in self.receipts:
                          self._remember(tid, error=reason)
                      self._reply(_ERROR, tid, seq, reason.encode('utf-8')[:180])

          def _remember(self, tid, **fields):
              self.receipts[tid] = dict(at=self.clock(), **fields)
              self.receipts.move_to_end(tid)
              while len(self.receipts) > 256:
                  self.receipts.popitem(last=False)

          def _receive_data(self, typ, tid, seq, body):
              if tid in self.receipts:
                  c = self.receipts[tid]
                  if 'error' in c:
                      self._reply(_ERROR, tid, seq, c['error'].encode('utf-8')[:180])
                  elif typ == _END and seq == c['seq'] and body == c['digest']:
                      self._reply(_ACK, tid, seq)  # Lost final ACK: never save twice.
                  return
              if typ == _META:
                  if seq != 0:
                      raise ValueError('Invalid metadata sequence')
                  if self.rx:
                      if self.rx['tid'] == tid and self.rx['meta'] == body:
                          self.rx['last'] = self.clock()
                          self._reply(_ACK, tid, seq)
                          return
                      raise ValueError('Receiver busy; retry after its current transfer')
                  meta = json.loads(body.decode('utf-8'))
                  if not isinstance(meta, dict):
                      raise ValueError('Invalid metadata')
                  size, chunk, window = meta.get('size'), meta.get('chunk'), meta.get('window')
                  digest, kind = meta.get('sha256'), meta.get('kind')
                  if type(size) is not int or not 0 <= size <= self.limit:
                      raise ValueError('Unsupported file size')
                  if type(chunk) is not int or not 128 <= chunk <= 1024:
                      raise ValueError('Invalid chunk size')
                  if type(window) is not int or not 1 <= window <= 64:
                      raise ValueError('Invalid window size')
                  if kind not in ('text', 'image', 'audio') or (kind == 'text' and size > 65536):
                      raise ValueError('Unsupported content type or text size')
                  if not isinstance(digest, str) or not re.fullmatch('[0-9a-f]{64}', digest):
                      raise ValueError('Invalid SHA-256')
                  if not isinstance(meta.get('name'), str) or len(meta['name']) > 200:
                      raise ValueError('Invalid filename')
                  self.directory.mkdir(parents=True, exist_ok=True)
                  f = tempfile.NamedTemporaryFile(mode='w+b', prefix='.incoming_',
                                                  suffix='.part', dir=self.directory, delete=False)
                  self.rx = dict(tid=tid, meta=body, kind=kind, name=self._safe_name(meta['name']),
                                 size=size, chunk=chunk, window=window, digest=digest,
                                 n=(size + chunk - 1) // chunk, next=1, done=0, buffer={},
                                 hash=hashlib.sha256(), file=f, temp=Path(f.name),
                                 started=self.clock(), last=self.clock())
                  self._event('rx', 'Receiving', self.rx)
                  self._reply(_ACK, tid, seq)
                  return
              r = self.rx
              if r is None or r['tid'] != tid:
                  raise ValueError('No matching transfer; send again from the beginning')
              r['last'] = self.clock()
              if typ == _DATA:
                  if not 1 <= seq <= r['n']:
                      raise ValueError('Invalid data sequence')
                  expected = min(r['chunk'], r['size'] - (seq - 1) * r['chunk'])
                  if len(body) != expected:
                      raise ValueError('Invalid chunk length')
                  if seq < r['next']:
                      self._reply(_ACK, tid, seq)  # Re-ACK without writing twice.
                      return
                  if seq >= r['next'] + r['window']:
                      return  # Out of receive window: do not ACK unretained data.
                  if seq not in r['buffer']:
                      r['buffer'][seq] = body
                      r['done'] += len(body)  # Unique accepted bytes, including buffered ones.
                  elif r['buffer'][seq] != body:
                      raise ValueError('Conflicting duplicate packet')
                  while r['next'] in r['buffer']:
                      contiguous = r['buffer'].pop(r['next'])
                      r['file'].write(contiguous)
                      r['hash'].update(contiguous)
                      r['next'] += 1
                  self._event('rx', 'Receiving', r)
                  self._reply(_ACK, tid, seq)
              elif typ == _END:
                  if seq != r['n'] + 1 or r['next'] != seq or r['done'] != r['size'] or r['buffer']:
                      raise ValueError('Incomplete file')
                  if body != bytes.fromhex(r['digest']) or r['hash'].hexdigest() != r['digest']:
                      raise ValueError('Whole-file SHA-256 mismatch')
                  r['file'].flush()
                  os.fsync(r['file'].fileno())
                  r['file'].close()
                  final = self.directory / (tid.hex() + '_' + r['name'])
                  os.replace(r['temp'], final)
                  self._remember(tid, seq=seq, digest=body)
                  self.rx = None
                  self._reply(_ACK, tid, seq)
                  self._event('rx', 'Complete — saved and verified', r, path=str(final))

          def tick(self):
              self._pump()
              now = self.clock()
              if self.rx and now - self.rx['last'] >= self.idle_timeout:
                  self._drop_rx('Timed out — partial file removed')
              for tid, entry in list(self.receipts.items()):
                  if now - entry['at'] > self.receipt_ttl:
                      del self.receipts[tid]

          def _abort_tx(self, reason):
              if self.tx:
                  t, self.tx = self.tx, None
                  self._reply(_CANCEL, t['tid'], 0)
                  self._event('tx', reason, t)

          def cancel(self):
              self._abort_tx('Cancelled — peer may have received some data')

          def _drop_rx(self, reason):
              r, self.rx = self.rx, None
              if r:
                  self._remember(r['tid'], error=reason)
                  try:
                      r['file'].close()
                  except OSError:
                      pass
                  try:
                      r['temp'].unlink(missing_ok=True)
                  except OSError as exc:
                      reason += '; partial-file cleanup failed: ' + str(exc)
                  self._event('rx', reason, r)

          def close(self):
              self.tx = None
              self._drop_rx('Stopped — partial file removed')


      class blk(gr.basic_block):
          def __init__(self, my_addr='A1', peer_addr='B1',
                       shared_key='u362K7J0T2sA_vB1C2D3E4F5G6H7I8J9K0L1M2N3O4P=',
                       receive_dir='./received_A1', max_retries=20, max_file_mb=16, packet_interval=0.005,
                       difs=0.010, slot_time=0.005, cw_min=8, cw_max=128,
                       cca_timeout=0.100, tx_guard=0.020):
              gr.basic_block.__init__(self, name='CSMA + Selective Repeat ARQ', in_sig=None, out_sig=None)
              self.commands, self.halt = queue.Queue(maxsize=2048), threading.Event()
              self.worker = None
              for port in ('commands', 'rx_in', 'cca'):
                  self.message_port_register_in(pmt.intern(port))
              for port in ('tx_out', 'events', 'rtt'):
                  self.message_port_register_out(pmt.intern(port))
              self.set_msg_handler(pmt.intern('commands'), self.command)
              self.set_msg_handler(pmt.intern('rx_in'), self.receive)
              self.set_msg_handler(pmt.intern('cca'), self.sense)
              self.access_config = dict(difs=difs, slot_time=slot_time, cw_min=cw_min,
                                        cw_max=cw_max, cca_timeout=cca_timeout, tx_guard=tx_guard)
              self.config = dict(my_addr=my_addr, peer_addr=peer_addr, shared_key=shared_key,
                                 receive_dir=receive_dir, emit=self.publish, event=self.event,
                                 max_retries=max_retries, max_file_mb=max_file_mb, packet_interval=packet_interval)
              self.core = TransferCore(**self.config)
              self.core.access = ChannelAccess(**self.access_config)

          def sense(self, msg):
              try:
                  report = decode(msg)
                  self.core.access.observe(report['busy'], float(report['observed']))
              except (ValueError, TypeError, KeyError):
                  self.core.access.observe(True, time.monotonic())

          def publish(self, raw):
              self.message_port_pub(pmt.intern('tx_out'), pdu(raw))

          def event(self, event):
              self.message_port_pub(pmt.intern('events'), control(event))

          def command(self, msg):
              try:
                  self.commands.put_nowait(('command', decode(msg)))
              except (ValueError, queue.Full) as exc:
                  self.event(dict(direction='notice', state='Command rejected: ' + str(exc)))

          def receive(self, msg):
              try:
                  raw = raw_pdu(msg)
                  if len(raw) <= 4092:
                      self.commands.put_nowait(('rx', raw))
              except (ValueError, TypeError, queue.Full):
                  pass

          def start(self):
              self.halt.clear()
              self.core = TransferCore(**self.config)
              self.core.access = ChannelAccess(**self.access_config)
              self.core.rtt_event = lambda kind, sample: self.message_port_pub(
                  pmt.intern('rtt'), control(dict(kind=kind, seconds=sample)))
              self.worker = threading.Thread(target=self.run, name='selective-repeat', daemon=True)
              self.worker.start()
              return True

          def run(self):
              try:
                  while not self.halt.is_set():
                      try:
                          op, value = self.commands.get(timeout=0.001)
                          if op == 'rx':
                              self.core.receive(value)
                          elif value['op'] == 'send':
                              try:
                                  self.core.send(**{k: v for k, v in value.items() if k != 'op'})
                              except (ValueError, OSError) as exc:
                                  self.event(dict(direction='notice', state=str(exc)))
                          elif value['op'] == 'cancel':
                              self.core.cancel()
                          elif value['op'] == 'rto_update':
                              self.core.rtos[value['kind']] = float(value['seconds'])
                      except queue.Empty:
                          pass
                      self.core.tick()
              except Exception as exc:
                  self.event(dict(direction='notice', state='ARQ worker stopped: ' + str(exc)))
              finally:
                  self.core.close()

          def stop(self):
              self.halt.set()
              if self.worker:
                  self.worker.join(timeout=3)
              return True
    cca_timeout: '0.1'
    comment: 'Initial CSMA: all frames contend; software timing needs RF validation.'
    cw_max: cw_max
    cw_min: cw_min
    difs: difs
    max_file_mb: '16'
    max_retries: '20'
    my_addr: my_addr
    packet_interval: '0.005'
    peer_addr: peer_addr
    receive_dir: receive_dir
    shared_key: shared_key
    slot_time: slot_time
    tx_guard: '0.020'
  states: {}
- name: window_size
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import json
      import math

      def control(value):
          return pmt.intern(json.dumps(value, separators=(',', ':'), allow_nan=False))


      def decode(message):
          value = json.loads(pmt.symbol_to_string(message))
          if not isinstance(value, dict):
              raise ValueError('Expected command dictionary')
          return value


      def pdu(raw):
          return pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw)))


      def raw_pdu(message):
          if not pmt.is_pair(message):
              raise ValueError('Expected byte PDU')
          body = pmt.cdr(message)
          if pmt.is_u8vector(body):
              return bytes(pmt.u8vector_elements(body))
          # HDLC deframer's binary blob is converted by PMT's numpy adapter.
          return bytes(pmt.to_python(body))


      KINDS = ('text', 'image', 'audio')


      def profile(text, image, audio, low, high, integer=False):
          values = [int(v) if integer else float(v) for v in (text, image, audio)]
          if any(not math.isfinite(v) or not low <= v <= high for v in values):
              raise ValueError('Profile values must be in %s..%s' % (low, high))
          return dict(zip(KINDS, values))


      class TimeoutPolicy:
          """RFC 6298-style estimator, with application-specific bounds (not TCP)."""
          def __init__(self, initial, floors, maximum=30.0):
              self.initial, self.floors, self.maximum = initial, floors, maximum
              if any(floors[k] > initial[k] for k in KINDS):
                  raise ValueError('RTO floor must not exceed its initial value')
              self.estimates = {}

          def observe(self, kind, sample):
              sample = float(sample)
              if kind not in self.initial or not math.isfinite(sample) or sample <= 0:
                  raise ValueError('Invalid RTT observation')
              if kind not in self.estimates:
                  srtt, variation = sample, sample / 2.0
              else:
                  srtt, variation = self.estimates[kind]
                  variation = 0.75 * variation + 0.25 * abs(srtt - sample)
                  srtt = 0.875 * srtt + 0.125 * sample
              self.estimates[kind] = srtt, variation
              return self.timeout(kind)

          def timeout(self, kind):
              if kind not in self.estimates:
                  return self.initial[kind]
              srtt, variation = self.estimates[kind]
              return min(self.maximum, max(self.floors[kind], srtt + max(0.01, 4 * variation)))


      class blk(gr.basic_block):
          def __init__(self, text_window=16, image_window=32, audio_window=64):
              gr.basic_block.__init__(self, name='Window Size Selection', in_sig=None, out_sig=None)
              self.windows = profile(text_window, image_window, audio_window, 1, 64, True)
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle)

          def handle(self, msg):
              command = decode(msg)
              if command.get('op') == 'send':
                  command['window_size'] = self.windows[command['kind']]
              self.message_port_pub(pmt.intern('out'), control(command))
    audio_window: '1'
    image_window: '1'
    text_window: '1'
  states: {}

connections:
- [ack_timeout, out, window_size, in]
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', carrier_sense, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_burst_rx, '0']
- [carrier_sense, cca, sr_arq, cca]
- [corr_est, '0', digital_linear_equalizer_0, '0']
- [decoded_bits_stream, '0', hdlc_rx, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0_0, '0', corr_est, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', qtgui_const_sink_x_2, '0']
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [fec_burst_rx, out, fec_decoder, in]
- [fec_decoder, out, hdlc_flush, in]
- [fec_encoder, out, epy_block_3, pdu_in]
- [gui_commands, out, payload_size, in]
- [hdlc_flush, out, decoded_bits_stream, pdus]
- [hdlc_rx, out, sr_arq, rx_in]
- [hdlc_tx, '0', pdu_tagged_stream_to_pdu_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']
- [payload_size, out, ack_timeout, in]
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_encoder, in]
- [sr_arq, events, gui_events, in]
- [sr_arq, rtt, ack_timeout, rtt]
- [sr_arq, tx_out, hdlc_tx, in]
- [window_size, out, sr_arq, commands]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
