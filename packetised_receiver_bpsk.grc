options:
  parameters:
    author: Pixel_Pulse
    generate_options: qt_gui
    id: Packetized_receiver_bpsk
    output_language: python
    title: CDP
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1100010111011000111110101000111101100010000001011010011100001101"'
  states: {}
- name: bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1,1] '
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1,]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: '1'
    step_size: '.01'
    type: cma
  states: {}
- name: costas_phase_bw
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.04'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: my_addr
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0,0.7,0.4,0.15]'
  states: {}
- name: timing_phase_bw
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '5e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_3
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '4'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_phase_bw
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '7'
    sps: '1'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1]'
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: timing_phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Received Message Display",
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(
                  pmt.intern("pdu_in")
              )

              self.message_port_register_out(
                  pmt.intern("text_out")
              )

              self.set_msg_handler(
                  pmt.intern("pdu_in"),
                  self.handle_msg
              )


          def handle_msg(self, msg):

              if not pmt.is_pair(msg):
                  return

              try:
                  raw_bytes = bytes(
                      pmt.u8vector_elements(
                          pmt.cdr(msg)
                      )
                  )

              except Exception as e:
                  print("[RX] Could not extract message:", e)
                  return


              # IMPORTANT:
              # CRC has already been removed by CRC Check.
              # Custom 7-byte packet header has already been
              # removed by Packet Parser.
              #
              # Therefore raw_bytes IS the actual message.

              try:
                  text = raw_bytes.decode(
                      "utf-8",
                      errors="replace"
                  )

              except Exception as e:
                  print("[RX] Decode error:", e)
                  return


              print("\n==============================")
              print("[RX] RECEIVED MESSAGE:", text)
              print("==============================\n")


              # Update Received Message QT box
              self.message_port_pub(
                  pmt.intern("text_out"),
                  pmt.intern(text)
              )
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import struct
      import time

      from gnuradio import gr
      import pmt


      MAX_PAYLOAD = 200
      MAX_SEGMENTS = 255
      MAX_ACTIVE_MESSAGES = 64
      REASSEMBLY_TIMEOUT = 10.0

      # Must exactly match the transmitter.
      HEADER_FORMAT = ">BBBIBBH"
      HEADER_LEN = struct.calcsize(HEADER_FORMAT)


      class blk(gr.basic_block):

          def __init__(self, my_addr=0x03):
              gr.basic_block.__init__(
                  self,
                  name="Safe Packet Parser",
                  in_sig=None,
                  out_sig=None
              )

              self.my_addr = my_addr & 0xFF
              self._reassembly = {}

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(
                  pmt.intern("pdu_in"),
                  self.handle_msg
              )

          def _remove_expired(self, now):
              expired_keys = [
                  key
                  for key, state in self._reassembly.items()
                  if now - state["updated"] > REASSEMBLY_TIMEOUT
              ]

              for key in expired_keys:
                  state = self._reassembly.pop(key)
                  print(
                      "[RX] Expired incomplete message",
                      key,
                      "received",
                      len(state["parts"]),
                      "of",
                      state["total"],
                      "segments"
                  )

          def _make_space(self):
              if len(self._reassembly) < MAX_ACTIVE_MESSAGES:
                  return

              # Remove the oldest incomplete message.
              oldest_key = min(
                  self._reassembly,
                  key=lambda key: self._reassembly[key]["updated"]
              )

              del self._reassembly[oldest_key]
              print("[RX] Removed oldest incomplete message:", oldest_key)

          def handle_msg(self, msg):
              now = time.monotonic()
              self._remove_expired(now)

              if not pmt.is_pair(msg):
                  print("[RX] Invalid PDU")
                  return

              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              if not pmt.is_u8vector(data):
                  print("[RX] PDU data is not a u8vector")
                  return

              try:
                  raw = bytes(pmt.u8vector_elements(data))
              except Exception as exc:
                  print("[RX] Could not extract packet:", exc)
                  return

              if len(raw) < HEADER_LEN:
                  print("[RX] Packet shorter than header")
                  return

              try:
                  (
                      src,
                      dst,
                      msg_type,
                      message_id,
                      seq,
                      total,
                      payload_len
                  ) = struct.unpack(
                      HEADER_FORMAT,
                      raw[:HEADER_LEN]
                  )
              except struct.error as exc:
                  print("[RX] Invalid header:", exc)
                  return

              # Accept packets addressed to this receiver or broadcast.
              if dst != self.my_addr and dst != 0xFF:
                  return

              if total == 0 or total > MAX_SEGMENTS:
                  print("[RX] Invalid segment total:", total)
                  return

              if seq >= total:
                  print(
                      "[RX] Invalid segment number:",
                      seq,
                      "total:",
                      total
                  )
                  return

              if payload_len > MAX_PAYLOAD:
                  print("[RX] Payload too large:", payload_len)
                  return

              # CRC has already been removed by the CRC Check block.
              expected_length = HEADER_LEN + payload_len

              if len(raw) != expected_length:
                  print(
                      "[RX] Packet length mismatch:",
                      len(raw),
                      "expected:",
                      expected_length
                  )
                  return

              payload = raw[HEADER_LEN:expected_length]
              key = (src, message_id, msg_type)

              state = self._reassembly.get(key)

              if state is None:
                  self._make_space()

                  state = {
                      "total": total,
                      "parts": {},
                      "bytes": 0,
                      "updated": now
                  }

                  self._reassembly[key] = state

              elif state["total"] != total:
                  # Same ID but conflicting header: discard the whole message.
                  del self._reassembly[key]
                  print("[RX] Conflicting segment total for:", key)
                  return

              existing = state["parts"].get(seq)

              if existing is not None:
                  if existing != payload:
                      # Two different payloads claim to be the same segment.
                      del self._reassembly[key]
                      print("[RX] Conflicting duplicate segment:", key, seq)
                  else:
                      print("[RX] Duplicate segment ignored:", key, seq)

                  return

              state["parts"][seq] = payload
              state["bytes"] += len(payload)
              state["updated"] = now

              if len(state["parts"]) < total:
                  return

              # Verify that every required sequence number exists.
              if not all(index in state["parts"] for index in range(total)):
                  return

              full_message = b"".join(
                  state["parts"][index]
                  for index in range(total)
              )

              del self._reassembly[key]

              output_vector = pmt.init_u8vector(
                  len(full_message),
                  list(full_message)
              )

              self.message_port_pub(
                  pmt.intern("pdu_out"),
                  pmt.cons(meta, output_vector)
              )

              print(
                  "[RX] Reassembled message ID",
                  message_id,
                  "from",
                  total,
                  "segment(s),",
                  len(full_message),
                  "bytes"
              )
    my_addr: '3'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    len_tag_key: '""'
    manual_gain1: '35'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: '''ip:192.168.1.10'''
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"After Costas Loop"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"After linear equilizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"RX-After Symbol Sync"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,2
    is_pair: 'False'
    label: Received Message
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"RX - Raw spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX - Raw IQ"'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX -After AGC"'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_check_0_0, ok, epy_block_1, pdu_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', qtgui_const_sink_x_1_0, '0']
- [epy_block_0, text_out, qtgui_edit_box_msg_0, val]
- [epy_block_1, pdu_out, blocks_message_debug_3, print_pdu]
- [epy_block_1, pdu_out, epy_block_0, pdu_in]
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
