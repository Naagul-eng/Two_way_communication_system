options:
  parameters:
    author: naagul
    description: 'Game-mode QPSK link: same PHY chain, small packets, light MAC+keystream instead of Fernet, no file/ARQ layer, TDMA uplink slots.'
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: game_loopback_sim
    output_language: python
    title: Among Us Lite v2 - laptop loopback simulation
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '"1110000101011010111010001001001111100001010110101110100010010011"'
  states: {}
- name: burst_prefix
  id: variable
  parameters:
    comment: Training prefix bytes per burst. Original file used 2048. Raise if packet loss appears.
    value: '640'
  states: {}
- name: burst_tail
  id: variable
  parameters:
    comment: Flush bytes per burst; must exceed one SDR buffer (4096 samples = 256 bytes) plus filter delay. Original file used 2570.
    value: '384'
  states: {}
- name: cma_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.001'
    type: cma
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fec_enabled
  id: variable
  parameters:
    comment: Enable/bypass on BOTH peers together; restart after changing.
    value: 'True'
  states: {}
- name: fec_log_every
  id: variable
  parameters:
    comment: Use 1 for every packet; 50 for file transfers.
    value: '50'
  states: {}
- name: fec_nsym
  id: variable
  parameters:
    comment: Parity bytes per codeword. Must match peer; restart after changing.
    value: '16'
  states: {}
- name: fec_verbose
  id: variable
  parameters:
    comment: Print corrections, failures and periodic packet counts.
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: game_key
  id: variable
  parameters:
    comment: Same on every node.
    value: '''change-this-game-key'''
  states: {}
- name: guard_ms
  id: variable
  parameters:
    comment: Delay after STATE before first client slot.
    value: '70'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: n_players
  id: variable
  parameters:
    comment: Total players incl. host (3..8).
    value: '4'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: node_id
  id: variable
  parameters:
    comment: 'Client: set 1..n_players-1 (one per laptop). Host is 0.'
    value: '1'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: slot_ms
  id: variable
  parameters:
    comment: Uplink slot per client. Must exceed one burst airtime + jitter.
    value: '45'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tick_ms
  id: variable
  parameters:
    comment: Host broadcast period. Lower = smoother but needs more airtime.
    value: '250'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channel_model_0
  id: channels_channel_model
  parameters:
    comment: AWGN only; add freq_offset (e.g. 0.002) to stress Costas
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.03'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_alg
    num_taps: '5'
    sps: '2'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    constellation: digital.constellation_qpsk().base()
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """Add a repeatable prefix and a tail outside the packet header and payload."""

      import hashlib
      import os

      from gnuradio import gr
      import pmt


      def training_bytes(length):
          output = bytearray()
          counter = 0

          while len(output) < length:
              output.extend(
                  hashlib.sha256(
                      b"QPSK-training-v1" + counter.to_bytes(4, "big")
                  ).digest()
              )
              counter += 1

          return bytes(output[:length])


      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=1500, num_tail_bytes=1024):
              gr.basic_block.__init__(
                  self,
                  name="Burst Prefix + Tail",
                  in_sig=None,
                  out_sig=None,
              )

              self.prefix = int(num_dummy_bytes)
              self.tail = int(num_tail_bytes)

              if self.prefix < 0 or self.tail < 0:
                  raise ValueError("Padding lengths must be nonnegative")

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  return

              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              padded = (
                  training_bytes(self.prefix)
                  + raw
                  + os.urandom(self.tail)
              )

              output = pmt.cons(
                  pmt.car(msg),
                  pmt.init_u8vector(len(padded), list(padded)),
              )
              self.message_port_pub(pmt.intern("pdu_out"), output)
    comment: Training prefix + tail per burst (variables burst_prefix / burst_tail)
    num_dummy_bytes: burst_prefix
    num_tail_bytes: burst_tail
  states: {}
- name: epy_rs_decoder
  id: epy_block
  parameters:
    _source_code: |
      """Inverse of rs_packet_encoder.py. Reassemble a complete PDU before CRC Check.
      A failed codeword drops the entire PDU; the existing ARQ retries the packet.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Correct each RS codeword, then emit the original encrypted frame plus CRC."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Decoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096
              self.max_coded = self.max_input + self.nsym * ((self.max_input+self.k-1)//self.k)
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.rx_count = self.fail_count = self.decoded_count = 0
              self.corrected_packets = self.corrected_bytes = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.message_port_register_out(pmt.intern('fail'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  if self.verbose:
                      print('[RS RX] DROP: expected a packed-byte PDU', flush=True)
                  return
              self.rx_count += 1
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              corrected, corrected_bits, nwords = 0, 0, 0
              try:
                  if self.enabled:
                      if not self.nsym+4 <= len(raw) <= self.max_coded:
                          raise ValueError('invalid coded packet length')
                      tail = len(raw) % 255
                      if tail and tail <= self.nsym:
                          raise ValueError('truncated final RS codeword')
                      parts = []
                      for i in range(0, len(raw), 255):
                          received_word = raw[i:i+255]
                          data, repaired_word, positions = self.rs.decode(received_word)
                          parts.append(bytes(data))
                          corrected += sum(a != b for a, b in zip(received_word, repaired_word))
                          corrected_bits += sum(bin(a ^ b).count('1') for a, b in zip(received_word, repaired_word))
                          nwords += 1
                      decoded = b''.join(parts)
                  else:
                      decoded = raw
                  if not 4 <= len(decoded) <= self.max_input:
                      raise ValueError('invalid decoded packet length')
              except (ReedSolomonError, ValueError) as exc:
                  self.fail_count += 1
                  self.message_port_pub(pmt.intern('fail'), msg)
                  if self.verbose:
                      print(f'[RS RX #{self.rx_count}] DROP: {exc}; '
                            f'RS failures={self.fail_count}; waiting for ARQ retry', flush=True)
                  return
              meta = pmt.car(msg)
              if not pmt.is_dict(meta):
                  meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bytes'), pmt.from_long(corrected))
              meta = pmt.dict_add(meta, pmt.intern('rs_corrected_bits'), pmt.from_long(corrected_bits))
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(decoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(decoded), list(decoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.decoded_count += 1
              self.corrected_packets += int(corrected > 0)
              self.corrected_bytes += corrected
              if self.verbose and (corrected or self.rx_count == 1 or
                                   self.rx_count % self.log_every == 0):
                  print(f'[RS RX #{self.rx_count}] {len(raw)} -> {len(decoded)} bytes; '
                        f'codewords={nwords}; corrected bytes={corrected}; '
                        'CRC/authentication/file verification follow', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS RX SUMMARY] received={self.rx_count}; decoded={self.decoded_count}; '
                        f'RS failures={self.fail_count}; corrected packets={self.corrected_packets}; '
                        f'corrected bytes={self.corrected_bytes}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: epy_rs_encoder
  id: epy_block
  parameters:
    _source_code: |
      """Multi-codeword RS FEC for encrypted transceiver PDUs, including CRC32.
      Each 239-byte segment gets 16 parity bytes at nsym=16. No extra wire header.
      """
      from gnuradio import gr
      import pmt
      # Reed-Solomon 1.7.0 source is bundled below; no pip dependency is needed.
      # The unmodified upstream source and its license are included for portability.
      import types as _types
      _REEDSOLO_LICENSE = 'The software is available under your choice of\nUnlicense (SPDX short identifier: Unlicense) or\nMIT No Attribution License (SPDX short identifier: MIT-0):\n\n-----\n\n<<START OF UNLICENSE>>\nThis is free and unencumbered software released into the public domain.\n\nAnyone is free to copy, modify, publish, use, compile, sell, or\ndistribute this software, either in source code form or as a compiled\nbinary, for any purpose, commercial or non-commercial, and by any\nmeans.\n\nIn jurisdictions that recognize copyright laws, the author or authors\nof this software dedicate any and all copyright interest in the\nsoftware to the public domain. We make this dedication for the benefit\nof the public at large and to the detriment of our heirs and\nsuccessors. We intend this dedication to be an overt act of\nrelinquishment in perpetuity of all present and future rights to this\nsoftware under copyright law.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND,\nEXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF\nMERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.\nIN NO EVENT SHALL THE AUTHORS BE LIABLE FOR ANY CLAIM, DAMAGES OR\nOTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE,\nARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR\nOTHER DEALINGS IN THE SOFTWARE.\n\nFor more information, please refer to <http://unlicense.org/>\n<<END OF UNLICENSE>>\n\n-----\n\n<<START OF MIT-0 LICENSE>>\nCopyright 2013-2023 Tomer Filiba & Stephen Larroque\n\nPermission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so.\n\nTHE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.\n<<END OF MIT-0 LICENSE>>\n'
      _REEDSOLO_SOURCE = '#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n\n# Copyright (c) 2012-2015 Tomer Filiba <tomerfiliba@gmail.com>\n# Copyright (c) 2015 rotorgit\n# Copyright (c) 2015-2022 Stephen Larroque <LRQ3000@gmail.com>\n\n\'\'\'\nReed Solomon\n============\n\nA pure-python `universal errors-and-erasures Reed-Solomon Codec <http://en.wikipedia.org/wiki/Reed%E2%80%93Solomon_error_correction>`_\n, based on the wonderful tutorial at\n`wikiversity <http://en.wikiversity.org/wiki/Reed%E2%80%93Solomon_codes_for_coders>`_,\nwritten by "Bobmath" and "LRQ3000".\n\nThe code of wikiversity is here consolidated into a nice API with exceptions handling.\nThe algorithm can correct up to 2*e+v <= nsym, where e is the number of errors,\nv the number of erasures and nsym = n-k = the number of ECC (error correction code) symbols.\nThis means that you can either correct exactly floor(nsym/2) errors, or nsym erasures\n(errors where you know the position), and a combination of both errors and erasures.\nThe code should work on pretty much any reasonable version of python (2.4-3.5),\nbut I\'m only testing on 2.7 - 3.4.\n\n.. note::\n   The codec is universal, meaning that it can decode any message encoded by another RS encoder\n   as long as you provide the correct parameters.\n   Note however that if you use higher fields (ie, bigger c_exp), the algorithms will be slower, first because\n   we cannot then use the optimized bytearray() structure but only array.array(\'i\', ...), and also because\n   Reed-Solomon\'s complexity is quadratic (both in encoding and decoding), so this means that the longer\n   your messages, the longer it will take to encode/decode (quadratically!).\n\n   The algorithm itself can handle messages up to (2^c_exp)-1 symbols, including the ECC symbols,\n   and each symbol can have a value of up to (2^c_exp)-1 (indeed, both the message length and the maximum\n   value for one character is constrained by the same mathematical reason). By default, we use the field GF(2^8),\n   which means that you are limited to values between 0 and 255 (perfect to represent a single hexadecimal\n   symbol on computers, so you can encode any binary stream) and limited to messages+ecc of maximum\n   length 255. However, you can "chunk" longer messages to fit them into the message length limit.\n   The ``RSCodec`` class will automatically apply chunking, by splitting longer messages into chunks and\n   encode/decode them separately; it shouldn\'t make a difference from an API perspective (ie, from your POV).\n\n::\n\n    # Initialization\n    >>> from reedsolo import RSCodec\n    >>> rsc = RSCodec(10)  # 10 ecc symbols\n\n    # Encoding\n    >>> rsc.encode([1,2,3,4])\n    b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\'\n    >>> rsc.encode(bytearray([1,2,3,4]))\n    bytearray(b\'\\x01\\x02\\x03\\x04,\\x9d\\x1c+=\\xf8h\\xfa\\x98M\')\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\'\n    # Note that chunking is supported transparently to encode any string length.\n\n    # Decoding (repairing)\n    >>> rsc.decode(b\'hello world\\xed%T\\xc4\\xfd\\xfd\\x89\\xf3\\xa8\\xaa\')[0]\n    b\'hello world\'\n    >>> rsc.decode(b\'heXlo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 3 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdX\\x89\\xf3\\xa8\\xaa\')[0]     # 5 errors\n    b\'hello world\'\n    >>> rsc.decode(b\'hXXXo worXd\\xed%T\\xc4\\xfdXX\\xf3\\xa8\\xaa\')[0]        # 6 errors - fail\n    Traceback (most recent call last):\n      ...\n    ReedSolomonError: Could not locate error\n\n    >>> rsc = RSCodec(12)  # using 2 more ecc symbols (to correct max 6 errors or 12 erasures)\n    >>> rsc.encode(b\'hello world\')\n    b\'hello world?Ay\\xb2\\xbc\\xdc\\x01q\\xb9\\xe3\\xe2=\'\n    >>> rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')[0]         # 6 errors - ok\n    b\'hello world\'\n    >>> rsc.decode(b\'helXXXXXXXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\', erase_pos=[3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 15, 16])[0]  # 12 erasures - OK\n    b\'hello world\'\n\n    # Checking\n    >> rsc.check(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    [False]\n    >> rmes, rmesecc = rsc.decode(b\'hello worXXXXy\\xb2XX\\x01q\\xb9\\xe3\\xe2=\')\n    >> rsc.check(rmesecc)\n    [True]\n\n    # To use longer chunks or bigger values than 255 (may be very slow)\n    >> rsc = RSCodec(12, nsize=4095)  # always use a power of 2 minus 1\n    >> rsc = RSCodec(12, c_exp=12)  # alternative way to set nsize=4095\n    >> mes = \'a\' * (4095-12)\n    >> mesecc = rsc.encode(mes)\n    >> mesecc[2] = 1\n    >> mesecc[-1] = 1\n    >> rmes, rmesecc = rsc.decode(mesecc)\n    >> rsc.check(mesecc)\n    [False]\n    >> rsc.check(rmesecc)\n    [True]\n\n    If you want full control, you can skip the API and directly use the library as-is. Here\'s how:\n\n    First you need to init the precomputed tables:\n    >> import reedsolo as rs\n    >> rs.init_tables(0x11d)\n    Pro tip: if you get the error: ValueError: byte must be in range(0, 256), please check that your prime polynomial is correct for your field.\n    Pro tip2: by default, you can only encode messages of max length and max symbol value = 256. If you want to encode bigger messages,\n    please use the following (where c_exp is the exponent of your Galois Field, eg, 12 = max length 2^12 = 4096):\n    >> prim = rs.find_prime_polys(c_exp=12, fast_primes=True, single=True)\n    >> rs.init_tables(c_exp=12, prim=prim)\n    \n    Let\'s define our RS message and ecc size:\n    >> n = 255  # length of total message+ecc\n    >> nsym = 12  # length of ecc\n    >> mes = "a" * (n-nsym)  # generate a sample message\n\n    To optimize, you can precompute the generator polynomial:\n    >> gen = rs.rs_generator_poly_all(n)\n\n    Then to encode:\n    >> mesecc = rs.rs_encode_msg(mes, nsym, gen=gen[nsym])\n\n    Let\'s tamper our message:\n    >> mesecc[1] = 0\n\n    To decode:\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym, erase_pos=erase_pos)\n    Note that both the message and the ecc are corrected (if possible of course).\n    Pro tip: if you know a few erasures positions, you can specify them in a list `erase_pos` to double the repair power. But you can also just specify an empty list.\n\n    If the decoding fails, it will normally automatically check and raise a ReedSolomonError exception that you can handle.\n    However if you want to manually check if the repaired message is correct, you can do so:\n    >> rs.rs_check(rmes + recc, nsym)\n\n    Note: if you want to use multiple reedsolomon with different parameters, you need to backup the globals and restore them before calling reedsolo functions:\n    >> rs.init_tables()\n    >> global gf_log, gf_exp, field_charac\n    >> bak_gf_log, bak_gf_exp, bak_field_charac = gf_log, gf_exp, field_charac\n    Then at anytime, you can do:\n    >> global gf_log, gf_exp, field_charac\n    >> gf_log, gf_exp, field_charac = bak_gf_log, bak_gf_exp, bak_field_charac\n    >> mesecc = rs.rs_encode_msg(mes, nsym)\n    >> rmes, recc, errata_pos = rs.rs_correct_msg(mesecc, nsym)\n    The globals backup is not necessary if you use RSCodec, it will be automatically managed.\n\n    Read the sourcecode\'s comments for more info about how it works, and for the various parameters you can setup if\n    you need to interface with other RS codecs.\n\n\'\'\'\n\n# TODO IMPORTANT: try to keep the same convention for the ordering of polynomials inside lists throughout the code and functions (because for now there are a lot of list reversing in order to make it work, you never know the order of a polynomial, ie, if the first coefficient is the major degree or the constant term...).\n\nimport itertools\nimport math\n\n\n################### INIT and stuff ###################\n\ntry:  # pragma: no cover\n    bytearray\n    _bytearray = bytearray\nexcept NameError:  # pragma: no cover\n    from array import array\n    def _bytearray(obj = 0, encoding = "latin-1"):  # pragma: no cover\n        \'\'\'Simple bytearray replacement\'\'\'\n        # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n        if isinstance(obj, str):\n            obj = [ord(ch) for ch in obj.encode(encoding)]\n        elif isinstance(obj, int):\n            obj = [0] * obj\n        return array("B", obj)\n\ntry:  # pragma: no cover\n    # compatibility with Python 2.7\n    xrange\nexcept NameError:  # pragma: no cover\n    # compatibility with Python 3+\n    xrange = range\n\nclass ReedSolomonError(Exception):\n    pass\n\ngf_exp = _bytearray([1] * 512) # For efficiency, gf_exp[] has size 2*GF_SIZE, so that a simple multiplication of two numbers can be resolved without calling % 255. For more infos on how to generate this extended exponentiation table, see paper: "Fast software implementation of finite field operations", Cheng Huang and Lihao Xu, Washington University in St. Louis, Tech. Rep (2003).\ngf_log = _bytearray(256)\nfield_charac = int(2**8 - 1)\n\n################### GALOIS FIELD ELEMENTS MATHS ###################\n\ndef rwh_primes1(n):\n    # http://stackoverflow.com/questions/2068372/fastest-way-to-list-all-primes-below-n-in-python/3035188#3035188\n    \'\'\' Returns  a list of primes < n \'\'\'\n    sieve = [True] * int(n/2)\n    for i in xrange(3,int(n**0.5)+1,2):\n        if sieve[int(i/2)]:\n            sieve[int((i*i)/2)::i] = [False] * int((n-i*i-1)/(2*i)+1)\n    return [2] + [2*i+1 for i in xrange(1,int(n/2)) if sieve[i]]\n\ndef find_prime_polys(generator=2, c_exp=8, fast_primes=False, single=False):\n    \'\'\'Compute the list of prime polynomials for the given generator and galois field characteristic exponent.\'\'\'\n    # fast_primes will output less results but will be significantly faster.\n    # single will output the first prime polynomial found, so if all you want is to just find one prime polynomial to generate the LUT for Reed-Solomon to work, then just use that.\n\n    # A prime polynomial (necessarily irreducible) is necessary to reduce the multiplications in the Galois Field, so as to avoid overflows.\n    # Why do we need a "prime polynomial"? Can\'t we just reduce modulo 255 (for GF(2^8) for example)? Because we need the values to be unique.\n    # For example: if the generator (alpha) = 2 and c_exp = 8 (GF(2^8) == GF(256)), then the generated Galois Field (0, 1, α, α^1, α^2, ..., α^(p-1)) will be galois field it becomes 0, 1, 2, 4, 8, 16, etc. However, upon reaching 128, the next value will be doubled (ie, next power of 2), which will give 256. Then we must reduce, because we have overflowed above the maximum value of 255. But, if we modulo 255, this will generate 256 == 1. Then 2, 4, 8, 16, etc. giving us a repeating pattern of numbers. This is very bad, as it\'s then not anymore a bijection (ie, a non-zero value doesn\'t have a unique index). That\'s why we can\'t just modulo 255, but we need another number above 255, which is called the prime polynomial.\n    # Why so much hassle? Because we are using precomputed look-up tables for multiplication: instead of multiplying a*b, we precompute alpha^a, alpha^b and alpha^(a+b), so that we can just use our lookup table at alpha^(a+b) and get our result. But just like in our original field we had 0,1,2,...,p-1 distinct unique values, in our "LUT" field using alpha we must have unique distinct values (we don\'t care that they are different from the original field as long as they are unique and distinct). That\'s why we need to avoid duplicated values, and to avoid duplicated values we need to use a prime irreducible polynomial.\n\n    # Here is implemented a bruteforce approach to find all these prime polynomials, by generating every possible prime polynomials (ie, every integers between field_charac+1 and field_charac*2), and then we build the whole Galois Field, and we reject the candidate prime polynomial if it duplicates even one value or if it generates a value above field_charac (ie, cause an overflow).\n    # Note that this algorithm is slow if the field is too big (above 12), because it\'s an exhaustive search algorithm. There are probabilistic approaches, and almost surely prime approaches, but there is no determistic polynomial time algorithm to find irreducible monic polynomials. More info can be found at: http://people.mpi-inf.mpg.de/~csaha/lectures/lec9.pdf\n    # Another faster algorithm may be found at Adleman, Leonard M., and Hendrik W. Lenstra. "Finding irreducible polynomials over finite fields." Proceedings of the eighteenth annual ACM symposium on Theory of computing. ACM, 1986.\n\n    # Prepare the finite field characteristic (2^p - 1), this also represent the maximum possible value in this field\n    root_charac = 2 # we\'re in GF(2)\n    field_charac = int(root_charac**c_exp - 1)\n    field_charac_next = int(root_charac**(c_exp+1) - 1)\n\n    prim_candidates = []\n    if fast_primes:\n        prim_candidates = rwh_primes1(field_charac_next) # generate maybe prime polynomials and check later if they really are irreducible\n        prim_candidates = [x for x in prim_candidates if x > field_charac] # filter out too small primes\n    else:\n        prim_candidates = xrange(field_charac+2, field_charac_next, root_charac) # try each possible prime polynomial, but skip even numbers (because divisible by 2 so necessarily not irreducible)\n\n    # Start of the main loop\n    correct_primes = []\n    for prim in prim_candidates: # try potential candidates primitive irreducible polys\n        seen = _bytearray(field_charac+1) # memory variable to indicate if a value was already generated in the field (value at index x is set to 1) or not (set to 0 by default)\n        conflict = False # flag to know if there was at least one conflict\n\n        # Second loop, build the whole Galois Field\n        x = 1\n        for i in xrange(field_charac):\n            # Compute the next value in the field (ie, the next power of alpha/generator)\n            x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n            # Rejection criterion: if the value overflowed (above field_charac) or is a duplicate of a previously generated power of alpha, then we reject this polynomial (not prime)\n            if x > field_charac or seen[x] == 1:\n                conflict = True\n                break\n            # Else we flag this value as seen (to maybe detect future duplicates), and we continue onto the next power of alpha\n            else:\n                seen[x] = 1\n\n        # End of the second loop: if there\'s no conflict (no overflow nor duplicated value), this is a prime polynomial!\n        if not conflict: \n            correct_primes.append(prim)\n            if single: return prim\n\n    # Return the list of all prime polynomials\n    return correct_primes # you can use the following to print the hexadecimal representation of each prime polynomial: print [hex(i) for i in correct_primes]\n\ndef init_tables(prim=0x11d, generator=2, c_exp=8):\n    \'\'\'Precompute the logarithm and anti-log tables for faster computation later, using the provided primitive polynomial.\n    These tables are used for multiplication/division since addition/substraction are simple XOR operations inside GF of characteristic 2.\n    The basic idea is quite simple: since b**(log_b(x), log_b(y)) == x * y given any number b (the base or generator of the logarithm), then we can use any number b to precompute logarithm and anti-log (exponentiation) tables to use for multiplying two numbers x and y.\n    That\'s why when we use a different base/generator number, the log and anti-log tables are drastically different, but the resulting computations are the same given any such tables.\n    For more infos, see https://en.wikipedia.org/wiki/Finite_field_arithmetic#Implementation_tricks\n    \'\'\'\n    # generator is the generator number (the "increment" that will be used to walk through the field by multiplication, this must be a prime number). This is basically the base of the logarithm/anti-log tables. Also often noted "alpha" in academic books.\n    # prim is the primitive/prime (binary) polynomial and must be irreducible (ie, it can\'t represented as the product of two smaller polynomials). It\'s a polynomial in the binary sense: each bit is a coefficient, but in fact it\'s an integer between field_charac+1 and field_charac*2, and not a list of gf values. The prime polynomial will be used to reduce the overflows back into the range of the Galois Field without duplicating values (all values should be unique). See the function find_prime_polys() and: http://research.swtch.com/field and http://www.pclviewer.com/rs2/galois.html\n    # note that the choice of generator or prime polynomial doesn\'t matter very much: any two finite fields of size p^n have identical structure, even if they give the individual elements different names (ie, the coefficients of the codeword will be different, but the final result will be the same: you can always correct as many errors/erasures with any choice for those parameters). That\'s why it makes sense to refer to all the finite fields, and all decoders based on Reed-Solomon, of size p^n as one concept: GF(p^n). It can however impact sensibly the speed (because some parameters will generate sparser tables).\n    # c_exp is the exponent for the field\'s characteristic GF(2^c_exp)\n\n    # Redefine _bytearray() in case we need to support integers or messages of length > 256\n    global _bytearray\n    if c_exp <= 8:\n        _bytearray = bytearray\n    else:\n        from array import array\n        def _bytearray(obj = 0, encoding = "latin-1"):\n            \'\'\'Fake bytearray replacement, supporting int values above 255\'\'\'\n            # always use Latin-1 and not UTF8 because Latin-1 maps the first 256 characters to their bytevalue equivalents. UTF8 may mangle your data (particularly at vale 128)\n            if isinstance(obj, str):  # obj is a string, convert to list of ints\n                obj = obj.encode(encoding)\n                if isinstance(obj, str):  # Py2 str: convert to list of ascii ints\n                    obj = [ord(chr) for chr in obj]\n                elif isinstance(obj, bytes):  # Py3 bytes: characters are bytes, need to convert to int for array.array(\'i\', obj)\n                    obj = [int(chr) for chr in obj]\n                else:\n                    raise(ValueError, "Type of object not recognized!")\n            elif isinstance(obj, int):  # compatibility with list preallocation bytearray(int)\n                obj = [0] * obj\n            elif isinstance(obj, bytes):\n                obj = [int(b) for b in obj]\n            # Else obj is a list of int, it\'s ok\n            return array("i", obj)\n\n    # Init global tables\n    global gf_exp, gf_log, field_charac\n    field_charac = int(2**c_exp - 1)\n    gf_exp = _bytearray(field_charac * 2) # anti-log (exponential) table. The first two elements will always be [GF256int(1), generator]\n    gf_log = _bytearray(field_charac+1) # log table, log[0] is impossible and thus unused\n\n    # For each possible value in the galois field 2^8, we will pre-compute the logarithm and anti-logarithm (exponential) of this value\n    # To do that, we generate the Galois Field F(2^p) by building a list starting with the element 0 followed by the (p-1) successive powers of the generator α : 1, α, α^1, α^2, ..., α^(p-1).\n    x = 1\n    for i in xrange(field_charac): # we could skip index 255 which is equal to index 0 because of modulo: g^255==g^0 but either way, this does not change the later outputs (ie, the ecc symbols will be the same either way)\n        gf_exp[i] = x # compute anti-log for this value and store it in a table\n        gf_log[x] = i # compute log at the same time\n        x = gf_mult_noLUT(x, generator, prim, field_charac+1)\n\n        # If you use only generator==2 or a power of 2, you can use the following which is faster than gf_mult_noLUT():\n        #x <<= 1 # multiply by 2 (change 1 by another number y to multiply by a power of 2^y)\n        #if x & 0x100: # similar to x >= 256, but a lot faster (because 0x100 == 256)\n            #x ^= prim # substract the primary polynomial to the current value (instead of 255, so that we get a unique set made of coprime numbers), this is the core of the tables generation\n\n    # Optimization: double the size of the anti-log table so that we don\'t need to mod 255 to stay inside the bounds (because we will mainly use this table for the multiplication of two GF numbers, no more).\n    for i in xrange(field_charac, field_charac * 2):\n        gf_exp[i] = gf_exp[i - field_charac]\n\n    return [gf_log, gf_exp, field_charac]\n\ndef gf_add(x, y):\n    return x ^ y\n\ndef gf_sub(x, y):\n    return x ^ y # in binary galois field, substraction is just the same as addition (since we mod 2)\n\ndef gf_neg(x):\n    return x\n\ndef gf_inverse(x):\n    return gf_exp[field_charac - gf_log[x]] # gf_inverse(x) == gf_div(1, x)\n\ndef gf_mul(x, y):\n    if x == 0 or y == 0:\n        return 0\n    return gf_exp[(gf_log[x] + gf_log[y]) % field_charac]\n\ndef gf_div(x, y):\n    if y == 0:\n        raise ZeroDivisionError()\n    if x == 0:\n        return 0\n    return gf_exp[(gf_log[x] + field_charac - gf_log[y]) % field_charac]\n\ndef gf_pow(x, power):\n    return gf_exp[(gf_log[x] * power) % field_charac]\n\ndef gf_mult_noLUT_slow(x, y, prim=0):\n    \'\'\'Multiplication in Galois Fields without using a precomputed look-up table (and thus it\'s slower) by using the standard carry-less multiplication + modular reduction using an irreducible prime polynomial.\'\'\'\n\n    ### Define bitwise carry-less operations as inner functions ###\n    def cl_mult(x,y):\n        \'\'\'Bitwise carry-less multiplication on integers\'\'\'\n        z = 0\n        i = 0\n        while (y>>i) > 0:\n            if y & (1<<i):\n                z ^= x<<i\n            i += 1\n        return z\n\n    def bit_length(n):\n        \'\'\'Compute the position of the most significant bit (1) of an integer. Equivalent to int.bit_length()\'\'\'\n        bits = 0\n        while n >> bits: bits += 1\n        return bits\n \n    def cl_div(dividend, divisor=None):\n        \'\'\'Bitwise carry-less long division on integers and returns the remainder\'\'\'\n        # Compute the position of the most significant bit for each integers\n        dl1 = bit_length(dividend)\n        dl2 = bit_length(divisor)\n        # If the dividend is smaller than the divisor, just exit\n        if dl1 < dl2:\n            return dividend\n        # Else, align the most significant 1 of the divisor to the most significant 1 of the dividend (by shifting the divisor)\n        for i in xrange(dl1-dl2,-1,-1):\n            # Check that the dividend is divisible (useless for the first iteration but important for the next ones)\n            if dividend & (1 << i+dl2-1):\n                # If divisible, then shift the divisor to align the most significant bits and XOR (carry-less substraction)\n                dividend ^= divisor << i\n        return dividend\n \n    ### Main GF multiplication routine ###\n \n    # Multiply the gf numbers\n    result = cl_mult(x,y)\n    # Then do a modular reduction (ie, remainder from the division) with an irreducible primitive polynomial so that it stays inside GF bounds\n    if prim > 0:\n        result = cl_div(result, prim)\n \n    return result\n\ndef gf_mult_noLUT(x, y, prim=0, field_charac_full=256, carryless=True):\n    \'\'\'Galois Field integer multiplication using Russian Peasant Multiplication algorithm (faster than the standard multiplication + modular reduction).\n    If prim is 0 and carryless=False, then the function produces the result for a standard integers multiplication (no carry-less arithmetics nor modular reduction).\'\'\'\n    r = 0\n    while y: # while y is above 0\n        if y & 1: r = r ^ x if carryless else r + x # y is odd, then add the corresponding x to r (the sum of all x\'s corresponding to odd y\'s will give the final product). Note that since we\'re in GF(2), the addition is in fact an XOR (very important because in GF(2) the multiplication and additions are carry-less, thus it changes the result!).\n        y = y >> 1 # equivalent to y // 2\n        x = x << 1 # equivalent to x*2\n        if prim > 0 and x & field_charac_full: x = x ^ prim # GF modulo: if x >= 256 then apply modular reduction using the primitive polynomial (we just substract, but since the primitive number can be above 256 then we directly XOR).\n\n    return r\n\n\n################### GALOIS FIELD POLYNOMIALS MATHS ###################\n\ndef gf_poly_scale(p, x):\n    return _bytearray([gf_mul(p[i], x) for i in xrange(len(p))])\n\ndef gf_poly_add(p, q):\n    r = _bytearray( max(len(p), len(q)) )\n    r[len(r)-len(p):len(r)] = p\n    #for i in xrange(len(p)):\n        #r[i + len(r) - len(p)] = p[i]\n    for i in xrange(len(q)):\n        r[i + len(r) - len(q)] ^= q[i]\n    return r\n\ndef gf_poly_mul(p, q):\n    \'\'\'Multiply two polynomials, inside Galois Field (but the procedure is generic). Optimized function by precomputation of log.\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Precompute the logarithm of p\n    lp = [gf_log[p[i]] for i in xrange(len(p))]\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        qj = q[j] # optimization: load the coefficient once\n        if qj != 0: # log(0) is undefined, we need to check that\n            lq = gf_log[qj] # Optimization: precache the logarithm of the current coefficient of q\n            for i in xrange(len(p)):\n                if p[i] != 0: # log(0) is undefined, need to check that...\n                    r[i + j] ^= gf_exp[lp[i] + lq] # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j]))\n    return r\n\ndef gf_poly_mul_simple(p, q): # simple equivalent way of multiplying two polynomials without precomputation, but thus it\'s slower\n    \'\'\'Multiply two polynomials, inside Galois Field\'\'\'\n    # Pre-allocate the result array\n    r = _bytearray(len(p) + len(q) - 1)\n    # Compute the polynomial multiplication (just like the outer product of two vectors, we multiply each coefficients of p with all coefficients of q)\n    for j in xrange(len(q)):\n        for i in xrange(len(p)):\n            r[i + j] ^= gf_mul(p[i], q[j]) # equivalent to: r[i + j] = gf_add(r[i+j], gf_mul(p[i], q[j])) -- you can see it\'s your usual polynomial multiplication\n    return r\n\ndef gf_poly_neg(poly):\n    \'\'\'Returns the polynomial with all coefficients negated. In GF(2^p), negation does not change the coefficient, so we return the polynomial as-is.\'\'\'\n    return poly\n\ndef gf_poly_div(dividend, divisor):\n    \'\'\'Fast polynomial division by using Extended Synthetic Division and optimized for GF(2^p) computations (doesn\'t work with standard polynomials outside of this galois field).\'\'\'\n    # CAUTION: this function expects polynomials to follow the opposite convention at decoding: the terms must go from the biggest to lowest degree (while most other functions here expect a list from lowest to biggest degree). eg: 1 + 2x + 5x^2 = [5, 2, 1], NOT [1, 2, 5]\n\n    msg_out = _bytearray(dividend) # Copy the dividend list and pad with 0 where the ecc bytes will be computed\n    #normalizer = divisor[0] # precomputing for performance\n    for i in xrange(len(dividend) - (len(divisor)-1)):\n        #msg_out[i] /= normalizer # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]. For more infos, see http://en.wikipedia.org/wiki/Synthetic_division\n        coef = msg_out[i] # precaching\n        if coef != 0: # log(0) is undefined, so we need to avoid that case explicitly (and it\'s also a good optimization). In fact if you remove it, it should still work because gf_mul() will take care of the condition. But it\'s still a good practice to put the condition here.\n            for j in xrange(1, len(divisor)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient\n                if divisor[j] != 0: # log(0) is undefined\n                    msg_out[i + j] ^= gf_mul(divisor[j], coef) # equivalent to the more mathematically correct (but xoring directly is faster): msg_out[i + j] += -divisor[j] * coef\n\n    # The resulting msg_out contains both the quotient and the remainder, the remainder being the size of the divisor (the remainder has necessarily the same degree as the divisor -- not length but degree == length-1 -- since it\'s what we couldn\'t divide from the dividend), so we compute the index where this separation is, and return the quotient and remainder.\n    separator = -(len(divisor)-1)\n    return msg_out[:separator], msg_out[separator:] # return quotient, remainder.\n\ndef gf_poly_square(poly):  # pragma: no cover\n    \'\'\'Linear time implementation of polynomial squaring. For details, see paper: "A fast software implementation for arithmetic operations in GF (2n)". De Win, E., Bosselaers, A., Vandenberghe, S., De Gersem, P., & Vandewalle, J. (1996, January). In Advances in Cryptology - Asiacrypt\'96 (pp. 65-76). Springer Berlin Heidelberg.\'\'\'\n    length = len(poly)\n    out = _bytearray(2*length - 1)\n    for i in xrange(length-1):\n        p = poly[i]\n        k = 2*i\n        if p != 0:\n            #out[k] = gf_exp[(2*gf_log[p]) % field_charac] # not necessary to modulo (2^r)-1 since gf_exp is duplicated up to 510.\n            out[k] = gf_exp[2*gf_log[p]]\n        #else: # not necessary since the output is already initialized to an array of 0\n            #out[k] = 0\n    out[2*length-2] = gf_exp[2*gf_log[poly[length-1]]]\n    if out[0] == 0: out[0] = 2*poly[1] - 1\n    return out\n\ndef gf_poly_eval(poly, x):\n    \'\'\'Evaluates a polynomial in GF(2^p) given the value for x. This is based on Horner\'s scheme for maximum efficiency.\'\'\'\n    y = poly[0]\n    for i in xrange(1, len(poly)):\n        y = gf_mul(y, x) ^ poly[i]\n    return y\n\n\n################### REED-SOLOMON ENCODING ###################\n\ndef rs_generator_poly(nsym, fcr=0, generator=2):\n    \'\'\'Generate an irreducible generator polynomial (necessary to encode a message into Reed-Solomon)\'\'\'\n    g = _bytearray([1])\n    for i in xrange(nsym):\n        g = gf_poly_mul(g, [1, gf_pow(generator, i+fcr)])\n    return g\n\ndef rs_generator_poly_all(max_nsym, fcr=0, generator=2):\n    \'\'\'Generate all irreducible generator polynomials up to max_nsym (usually you can use n, the length of the message+ecc). Very useful to reduce processing time if you want to encode using variable schemes and nsym rates.\'\'\'\n    g_all = {}\n    g_all[0] = g_all[1] = _bytearray([1])\n    for nsym in xrange(max_nsym):\n        g_all[nsym] = rs_generator_poly(nsym, fcr, generator)\n    return g_all\n\ndef rs_simple_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Simple Reed-Solomon encoding (mainly an example for you to understand how it works, because it\'s slower than the inlined function below)\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    # Pad the message, then divide it by the irreducible generator polynomial\n    _, remainder = gf_poly_div(msg_in + _bytearray(len(gen)-1), gen)\n    # The remainder is our RS code! Just append it to our original message to get our full codeword (this represents a polynomial of max 256 terms)\n    msg_out = msg_in + remainder\n    # Return the codeword\n    return msg_out\n\ndef rs_encode_msg(msg_in, nsym, fcr=0, generator=2, gen=None):\n    \'\'\'Reed-Solomon main encoding function, using polynomial division (Extended Synthetic Division, the fastest algorithm available to my knowledge), better explained at http://research.swtch.com/field\'\'\'\n    global field_charac\n    if (len(msg_in) + nsym) > field_charac: raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in)+nsym, field_charac))\n    if gen is None: gen = rs_generator_poly(nsym, fcr, generator)\n\n    msg_in = _bytearray(msg_in)\n    msg_out = _bytearray(msg_in) + _bytearray(len(gen)-1) # init msg_out with the values inside msg_in and pad with len(gen)-1 bytes (which is the number of ecc symbols).\n\n    # Precompute the logarithm of every items in the generator\n    lgen = _bytearray([gf_log[gen[j]] for j in xrange(len(gen))])\n\n    # Extended synthetic division main loop\n    # Fastest implementation with PyPy (but the Cython version in creedsolo.pyx is about 2x faster)\n    for i in xrange(len(msg_in)):\n        coef = msg_out[i] # Note that it\'s msg_out here, not msg_in. Thus, we reuse the updated value at each iteration (this is how Synthetic Division works: instead of storing in a temporary register the intermediate values, we directly commit them to the output).\n        # coef = gf_mul(msg_out[i], gf_inverse(gen[0]))  # for general polynomial division (when polynomials are non-monic), the usual way of using synthetic division is to divide the divisor g(x) with its leading coefficient (call it a). In this implementation, this means:we need to compute: coef = msg_out[i] / gen[0]\n        if coef != 0: # log(0) is undefined, so we need to manually check for this case. There\'s no need to check the divisor here because we know it can\'t be 0 since we generated it.\n            lcoef = gf_log[coef] # precaching\n\n            for j in xrange(1, len(gen)): # in synthetic division, we always skip the first coefficient of the divisior, because it\'s only used to normalize the dividend coefficient (which is here useless since the divisor, the generator polynomial, is always monic)\n                #if gen[j] != 0: # log(0) is undefined so we need to check that, but it slow things down in fact and it\'s useless in our case (reed-solomon encoding) since we know that all coefficients in the generator are not 0\n                msg_out[i + j] ^= gf_exp[lcoef + lgen[j]] # optimization, equivalent to gf_mul(gen[j], msg_out[i]) and we just substract it to msg_out[i+j] (but since we are in GF256, it\'s equivalent to an addition and to an XOR). In other words, this is simply a "multiply-accumulate operation"\n\n    # Recopy the original message bytes (overwrites the part where the quotient was computed)\n    msg_out[:len(msg_in)] = msg_in # equivalent to c = mprime - b, where mprime is msg_in padded with [0]*nsym\n    return msg_out\n\n\n################### REED-SOLOMON DECODING ###################\n\ndef rs_calc_syndromes(msg, nsym, fcr=0, generator=2):\n    \'\'\'Given the received codeword msg and the number of error correcting symbols (nsym), computes the syndromes polynomial.\n    Mathematically, it\'s essentially equivalent to a Fourrier Transform (Chien search being the inverse).\n    \'\'\'\n    # Note the "[0] +" : we add a 0 coefficient for the lowest degree (the constant). This effectively shifts the syndrome, and will shift every computations depending on the syndromes (such as the errors locator polynomial, errors evaluator polynomial, etc. but not the errors positions).\n    # This is not necessary as anyway syndromes are defined such as there are only non-zero coefficients (the only 0 is the shift of the constant here) and subsequent computations will/must account for the shift by skipping the first iteration (eg, the often seen range(1, n-k+1)), but you can also avoid prepending the 0 coeff and adapt every subsequent computations to start from 0 instead of 1.\n    return [0] + [gf_poly_eval(msg, gf_pow(generator, i+fcr)) for i in xrange(nsym)]\n\ndef rs_correct_errata(msg_in, synd, err_pos, fcr=0, generator=2): # err_pos is a list of the positions of the errors/erasures/errata\n    \'\'\'Forney algorithm, computes the values (error magnitude) to correct the input message.\'\'\'\n    global field_charac\n    msg = _bytearray(msg_in)\n    # calculate errata locator polynomial to correct both errors and erasures (by combining the errors positions given by the error locator polynomial found by BM with the erasures positions given by caller)\n    coef_pos = [len(msg) - 1 - p for p in err_pos] # need to convert the positions to coefficients degrees for the errata locator algo to work (eg: instead of [0, 1, 2] it will become [len(msg)-1, len(msg)-2, len(msg) -3])\n    err_loc = rs_find_errata_locator(coef_pos, generator)\n    # calculate errata evaluator polynomial (often called Omega or Gamma in academic papers)\n    err_eval = rs_find_error_evaluator(synd[::-1], err_loc, len(err_loc)-1)[::-1]\n\n    # Second part of Chien search to get the error location polynomial X from the error positions in err_pos (the roots of the error locator polynomial, ie, where it evaluates to 0)\n    X = [] # will store the position of the errors\n    for i in xrange(len(coef_pos)):\n        l = field_charac - coef_pos[i]\n        X.append( gf_pow(generator, -l) )\n\n    # Forney algorithm: compute the magnitudes\n    E = _bytearray(len(msg)) # will store the values that need to be corrected (substracted) to the message containing errors. This is sometimes called the error magnitude polynomial.\n    Xlength = len(X)\n    for i, Xi in enumerate(X):\n\n        Xi_inv = gf_inverse(Xi)\n\n        # Compute the formal derivative of the error locator polynomial (see Blahut, Algebraic codes for data transmission, pp 196-197).\n        # the formal derivative of the errata locator is used as the denominator of the Forney Algorithm, which simply says that the ith error value is given by error_evaluator(gf_inverse(Xi)) / error_locator_derivative(gf_inverse(Xi)). See Blahut, Algebraic codes for data transmission, pp 196-197.\n        err_loc_prime_tmp = []\n        for j in xrange(Xlength):\n            if j != i:\n                err_loc_prime_tmp.append( gf_sub(1, gf_mul(Xi_inv, X[j])) )\n        # compute the product, which is the denominator of the Forney algorithm (errata locator derivative)\n        err_loc_prime = 1\n        for coef in err_loc_prime_tmp:\n            err_loc_prime = gf_mul(err_loc_prime, coef)\n        # equivalent to: err_loc_prime = functools.reduce(gf_mul, err_loc_prime_tmp, 1)\n\n        # Test if we could find the errata locator, else we raise an Exception (because else since we divide y by err_loc_prime to compute the magnitude, we will get a ZeroDivisionError exception otherwise)\n        if err_loc_prime == 0:\n            raise ReedSolomonError("Decoding failed: Forney algorithm could not properly detect where the errors are located (errata locator prime is 0).")\n\n        # Compute y (evaluation of the errata evaluator polynomial)\n        # This is a more faithful translation of the theoretical equation contrary to the old forney method. Here it is exactly copy/pasted from the included presentation decoding_rs.pdf: Yl = omega(Xl.inverse()) / prod(1 - Xj*Xl.inverse()) for j in len(X) (in the paper it\'s for j in s, but it\'s useless when len(X) < s because we compute neutral terms 1 for nothing, and wrong when correcting more than s erasures or erasures+errors since it prevents computing all required terms).\n        # Thus here this method works with erasures too because firstly we fixed the equation to be like the theoretical one (don\'t know why it was modified in _old_forney(), if it\'s an optimization, it doesn\'t enhance anything), and secondly because we removed the product bound on s, which prevented computing errors and erasures above the s=(n-k)//2 bound.\n        y = gf_poly_eval(err_eval[::-1], Xi_inv) # numerator of the Forney algorithm (errata evaluator evaluated)\n        y = gf_mul(gf_pow(Xi, 1-fcr), y) # adjust to fcr parameter\n        \n        # Compute the magnitude\n        magnitude = gf_div(y, err_loc_prime) # magnitude value of the error, calculated by the Forney algorithm (an equation in fact): dividing the errata evaluator with the errata locator derivative gives us the errata magnitude (ie, value to repair) the ith symbol\n        E[err_pos[i]] = magnitude # store the magnitude for this error into the magnitude polynomial\n\n    # Apply the correction of values to get our message corrected! (note that the ecc bytes also gets corrected!)\n    # (this isn\'t the Forney algorithm, we just apply the result of decoding here)\n    msg = gf_poly_add(msg, E) # equivalent to Ci = Ri - Ei where Ci is the correct message, Ri the received (senseword) message, and Ei the errata magnitudes (minus is replaced by XOR since it\'s equivalent in GF(2^p)). So in fact here we substract from the received message the errors magnitude, which logically corrects the value to what it should be.\n    return msg\n\ndef rs_find_error_locator(synd, nsym, erase_loc=None, erase_count=0):\n    \'\'\'Find error/errata locator and evaluator polynomials with Berlekamp-Massey algorithm\'\'\'\n    # The idea is that BM will iteratively estimate the error locator polynomial.\n    # To do this, it will compute a Discrepancy term called Delta, which will tell us if the error locator polynomial needs an update or not\n    # (hence why it\'s called discrepancy: it tells us when we are getting off board from the correct value).\n\n    # Init the polynomials\n    if erase_loc: # if the erasure locator polynomial is supplied, we init with its value, so that we include erasures in the final locator polynomial\n        err_loc = _bytearray(erase_loc)\n        old_loc = _bytearray(erase_loc)\n    else:\n        err_loc = _bytearray([1]) # This is the main variable we want to fill, also called Sigma in other notations or more formally the errors/errata locator polynomial.\n        old_loc = _bytearray([1]) # BM is an iterative algorithm, and we need the errata locator polynomial of the previous iteration in order to update other necessary variables.\n    #L = 0 # update flag variable, not needed here because we use an alternative equivalent way of checking if update is needed (but using the flag could potentially be faster depending on if using length(list) is taking linear time in your language, here in Python it\'s constant so it\'s as fast.\n\n    # Fix the syndrome shifting: when computing the syndrome, some implementations may prepend a 0 coefficient for the lowest degree term (the constant). This is a case of syndrome shifting, thus the syndrome will be bigger than the number of ecc symbols (I don\'t know what purpose serves this shifting). If that\'s the case, then we need to account for the syndrome shifting when we use the syndrome such as inside BM, by skipping those prepended coefficients.\n    # Another way to detect the shifting is to detect the 0 coefficients: by definition, a syndrome does not contain any 0 coefficient (except if there are no errors/erasures, in this case they are all 0). This however doesn\'t work with the modified Forney syndrome, which set to 0 the coefficients corresponding to erasures, leaving only the coefficients corresponding to errors.\n    synd_shift = 0\n    if len(synd) > nsym: synd_shift = len(synd) - nsym\n\n    for i in xrange(nsym-erase_count): # generally: nsym-erase_count == len(synd), except when you input a partial erase_loc and using the full syndrome instead of the Forney syndrome, in which case nsym-erase_count is more correct (len(synd) will fail badly with IndexError).\n        if erase_loc: # if an erasures locator polynomial was provided to init the errors locator polynomial, then we must skip the FIRST erase_count iterations (not the last iterations, this is very important!)\n            K = erase_count+i+synd_shift\n        else: # if erasures locator is not provided, then either there\'s no erasures to account or we use the Forney syndromes, so we don\'t need to use erase_count nor erase_loc (the erasures have been trimmed out of the Forney syndromes).\n            K = i+synd_shift\n\n        # Compute the discrepancy Delta\n        # Here is the close-to-the-books operation to compute the discrepancy Delta: it\'s a simple polynomial multiplication of error locator with the syndromes, and then we get the Kth element.\n        #delta = gf_poly_mul(err_loc[::-1], synd)[K] # theoretically it should be gf_poly_add(synd[::-1], [1])[::-1] instead of just synd, but it seems it\'s not absolutely necessary to correctly decode.\n        # But this can be optimized: since we only need the Kth element, we don\'t need to compute the polynomial multiplication for any other element but the Kth. Thus to optimize, we compute the polymul only at the item we need, skipping the rest (avoiding a nested loop, thus we are linear time instead of quadratic).\n        # This optimization is actually described in several figures of the book "Algebraic codes for data transmission", Blahut, Richard E., 2003, Cambridge university press.\n        delta = synd[K]\n        for j in xrange(1, len(err_loc)):\n            delta ^= gf_mul(err_loc[-(j+1)], synd[K - j]) # delta is also called discrepancy. Here we do a partial polynomial multiplication (ie, we compute the polynomial multiplication only for the term of degree K). Should be equivalent to brownanrs.polynomial.mul_at().\n        #print "delta", K, delta, list(gf_poly_mul(err_loc[::-1], synd)) # debugline\n\n        # Shift polynomials to compute the next degree\n        old_loc = old_loc + _bytearray([0])\n\n        # Iteratively estimate the errata locator and evaluator polynomials\n        if delta != 0: # Update only if there\'s a discrepancy\n            if len(old_loc) > len(err_loc): # Rule B (rule A is implicitly defined because rule A just says that we skip any modification for this iteration)\n            #if 2*L <= K+erase_count: # equivalent to len(old_loc) > len(err_loc), as long as L is correctly computed\n                # Computing errata locator polynomial Sigma\n                new_loc = gf_poly_scale(old_loc, delta)\n                old_loc = gf_poly_scale(err_loc, gf_inverse(delta)) # effectively we are doing err_loc * 1/delta = err_loc // delta\n                err_loc = new_loc\n                # Update the update flag\n                #L = K - L # the update flag L is tricky: in Blahut\'s schema, it\'s mandatory to use `L = K - L - erase_count` (and indeed in a previous draft of this function, if you forgot to do `- erase_count` it would lead to correcting only 2*(errors+erasures) <= (n-k) instead of 2*errors+erasures <= (n-k)), but in this latest draft, this will lead to a wrong decoding in some cases where it should correctly decode! Thus you should try with and without `- erase_count` to update L on your own implementation and see which one works OK without producing wrong decoding failures.\n\n            # Update with the discrepancy\n            err_loc = gf_poly_add(err_loc, gf_poly_scale(old_loc, delta))\n\n    # Check if the result is correct, that there\'s not too many errors to correct\n    err_loc = list(itertools.dropwhile(lambda x: x == 0, err_loc)) # drop leading 0s, else errs will not be of the correct size\n    errs = len(err_loc) - 1\n    if (errs-erase_count) * 2 + erase_count > nsym:\n        raise ReedSolomonError("Too many errors to correct")\n\n    return err_loc\n\ndef rs_find_errata_locator(e_pos, generator=2):\n    \'\'\'Compute the erasures/errors/errata locator polynomial from the erasures/errors/errata positions (the positions must be relative to the x coefficient, eg: "hello worldxxxxxxxxx" is tampered to "h_ll_ worldxxxxxxxxx" with xxxxxxxxx being the ecc of length n-k=9, here the string positions are [1, 4], but the coefficients are reversed since the ecc characters are placed as the first coefficients of the polynomial, thus the coefficients of the erased characters are n-1 - [1, 4] = [18, 15] = erasures_loc to be specified as an argument.\'\'\'\n    # See: http://ocw.usu.edu/Electrical_and_Computer_Engineering/Error_Control_Coding/lecture7.pdf and Blahut, Richard E. "Transform techniques for error control codes." IBM Journal of Research and development 23.3 (1979): 299-315. http://citeseerx.ist.psu.edu/viewdoc/download?doi=10.1.1.92.600&rep=rep1&type=pdf and also a MatLab implementation here: http://www.mathworks.com/matlabcentral/fileexchange/23567-reed-solomon-errors-and-erasures-decoder/content//RS_E_E_DEC.m\n    e_loc = [1] # just to init because we will multiply, so it must be 1 so that the multiplication starts correctly without nulling any term\n    # erasures_loc is very simple to compute: erasures_loc = prod(1 - x*alpha**i) for i in erasures_pos and where alpha is the alpha chosen to evaluate polynomials (here in this library it\'s gf(3)). To generate c*x where c is a constant, we simply generate a Polynomial([c, 0]) where 0 is the constant and c is positionned to be the coefficient for x^1.\n    for i in e_pos:\n        e_loc = gf_poly_mul( e_loc, gf_poly_add(_bytearray([1]), [gf_pow(generator, i), 0]) )\n    return e_loc\n\ndef rs_find_error_evaluator(synd, err_loc, nsym):\n    \'\'\'Compute the error (or erasures if you supply sigma=erasures locator polynomial, or errata) evaluator polynomial Omega from the syndrome and the error/erasures/errata locator Sigma. Omega is already computed at the same time as Sigma inside the Berlekamp-Massey implemented above, but in case you modify Sigma, you can recompute Omega afterwards using this method, or just ensure that Omega computed by BM is correct given Sigma.\'\'\'\n    # Omega(x) = [ Synd(x) * Error_loc(x) ] mod x^(n-k+1)\n    _, remainder = gf_poly_div( gf_poly_mul(synd, err_loc), ([1] + [0]*(nsym+1)) ) # first multiply syndromes * errata_locator, then do a polynomial division to truncate the polynomial to the required length\n\n    # Faster way that is equivalent\n    #remainder = gf_poly_mul(synd, err_loc) # first multiply the syndromes with the errata locator polynomial\n    #remainder = remainder[len(remainder)-(nsym+1):] # then divide by a polynomial of the length we want, which is equivalent to slicing the list (which represents the polynomial)\n\n    return remainder\n\ndef rs_find_errors(err_loc, nmess, generator=2):\n    \'\'\'Find the roots (ie, where evaluation = zero) of error polynomial by bruteforce trial, this is a sort of Chien\'s search (but less efficient, Chien\'s search is a way to evaluate the polynomial such that each evaluation only takes constant time).\'\'\'\n    # nmess = length of whole codeword (message + ecc symbols)\n    errs = len(err_loc) - 1\n    err_pos = []\n    for i in xrange(nmess): # normally we should try all 2^8 possible values, but here we optimize to just check the interesting symbols\n        if gf_poly_eval(err_loc, gf_pow(generator, i)) == 0: # It\'s a 0? Bingo, it\'s a root of the error locator polynomial, in other terms this is the location of an error\n            err_pos.append(nmess - 1 - i)\n    # Sanity check: the number of errors/errata positions found should be exactly the same as the length of the errata locator polynomial\n    if len(err_pos) != errs:\n        # TODO: to decode messages+ecc with length n > 255, we may try to use a bruteforce approach: the correct positions ARE in the final array j, but the problem is because we are above the Galois Field\'s range, there is a wraparound so that for example if j should be [0, 1, 2, 3], we will also get [255, 256, 257, 258] (because 258 % 255 == 3, same for the other values), so we can\'t discriminate. The issue is that fixing any errs_nb errors among those will always give a correct output message (in the sense that the syndrome will be all 0), so we may not even be able to check if that\'s correct or not, so I\'m not sure the bruteforce approach may even be possible.\n        raise ReedSolomonError("Too many (or few) errors found by Chien Search for the errata locator polynomial!")\n    return err_pos\n\ndef rs_forney_syndromes(synd, pos, nmess, generator=2):\n    # Compute Forney syndromes, which computes a modified syndromes to compute only errors (erasures are trimmed out). Do not confuse this with Forney algorithm, which allows to correct the message based on the location of errors.\n    erase_pos_reversed = [nmess-1-p for p in pos] # prepare the coefficient degree positions (instead of the erasures positions)\n\n    # Optimized method, all operations are inlined\n    fsynd = list(synd[1:])      # make a copy and trim the first coefficient which is always 0 by definition\n    for i in xrange(len(pos)):\n        x = gf_pow(generator, erase_pos_reversed[i])\n        for j in xrange(len(fsynd) - 1):\n            fsynd[j] = gf_mul(fsynd[j], x) ^ fsynd[j + 1]\n        #fsynd.pop() # useless? it doesn\'t change the results of computations to leave it there\n\n    # Theoretical way of computing the modified Forney syndromes: fsynd = (erase_loc * synd) % x^(n-k) -- although the trimming by using x^(n-k) is maybe not necessary as many books do not even mention it (and it works without trimming)\n    # See Shao, H. M., Truong, T. K., Deutsch, L. J., & Reed, I. S. (1986, April). A single chip VLSI Reed-Solomon decoder. In Acoustics, Speech, and Signal Processing, IEEE International Conference on ICASSP\'86. (Vol. 11, pp. 2151-2154). IEEE.ISO 690\n    #erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator) # computing the erasures locator polynomial\n    #fsynd = gf_poly_mul(erase_loc[::-1], synd[1:]) # then multiply with the syndrome to get the untrimmed forney syndrome\n    #fsynd = fsynd[len(pos):] # then trim the first erase_pos coefficients which are useless. Seems to be not necessary, but this reduces the computation time later in BM (thus it\'s an optimization).\n\n    return fsynd\n\ndef rs_correct_msg(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        # Note that it is in fact possible to encode/decode messages that are longer than field_charac, but because this will be above the field, this will generate more error positions during Chien Search than it should, because this will generate duplicate values, which should normally be prevented thank\'s to the prime polynomial reduction (eg, because it can\'t discriminate between error at position 1 or 256, both being exactly equal under galois field 2^8). So it\'s really not advised to do it, but it\'s possible (but then you\'re not guaranted to be able to correct any error/erasure on symbols with a position above the length of field_charac -- if you really need a bigger message without chunking, then you should better enlarge c_exp so that you get a bigger field).\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures to correct (beyond the Singleton bound)\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], erase_pos  # no errors\n\n    # Find errors locations\n    if only_erasures:\n        err_pos = []\n    else:\n        # compute the Forney syndromes, which hide the erasures from the original syndrome (so that BM will just have to deal with errors, not erasures)\n        fsynd = rs_forney_syndromes(synd, erase_pos, len(msg_out), generator)\n        # compute the error locator polynomial using Berlekamp-Massey\n        err_loc = rs_find_error_locator(fsynd, nsym, erase_count=len(erase_pos))\n        # locate the message errors using Chien search (or bruteforce search)\n        err_pos = rs_find_errors(err_loc[::-1], len(msg_out), generator)\n        if err_pos is None:\n            raise ReedSolomonError("Could not locate error")\n\n    # Find errors values and apply them to correct the message\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, erase_pos + err_pos, fcr, generator) # note that we here use the original syndrome, not the forney syndrome (because we will correct both errors and erasures, so we need the full syndrome)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_correct_msg_nofsynd(msg_in, nsym, fcr=0, generator=2, erase_pos=None, only_erasures=False):\n    \'\'\'Reed-Solomon main decoding function, without using the modified Forney syndromes\'\'\'\n    global field_charac\n    if len(msg_in) > field_charac:\n        raise ValueError("Message is too long (%i when max is %i)" % (len(msg_in), field_charac))\n\n    msg_out = _bytearray(msg_in)     # copy of message\n    # erasures: set them to null bytes for easier decoding (but this is not necessary, they will be corrected anyway, but debugging will be easier with null bytes because the error locator polynomial values will only depend on the errors locations, not their values)\n    if erase_pos is None:\n        erase_pos = []\n    else:\n        for e_pos in erase_pos:\n            msg_out[e_pos] = 0\n    # check if there are too many erasures\n    if len(erase_pos) > nsym: raise ReedSolomonError("Too many erasures to correct")\n    # prepare the syndrome polynomial using only errors (ie: errors = characters that were either replaced by null byte or changed to another character, but we don\'t know their positions)\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    # check if there\'s any error/erasure in the input codeword. If not (all syndromes coefficients are 0), then just return the codeword as-is.\n    if max(synd) == 0:\n        return msg_out[:-nsym], msg_out[-nsym:], []  # no errors\n\n    # prepare erasures locator and evaluator polynomials\n    erase_loc = None\n    #erase_eval = None\n    erase_count = 0\n    if erase_pos:\n        erase_count = len(erase_pos)\n        erase_pos_reversed = [len(msg_out)-1-eras for eras in erase_pos]\n        erase_loc = rs_find_errata_locator(erase_pos_reversed, generator=generator)\n        #erase_eval = rs_find_error_evaluator(synd[::-1], erase_loc, len(erase_loc)-1)\n\n    # prepare errors/errata locator polynomial\n    if only_erasures:\n        err_loc = erase_loc[::-1]\n        #err_eval = erase_eval[::-1]\n    else:\n        err_loc = rs_find_error_locator(synd, nsym, erase_loc=erase_loc, erase_count=erase_count)\n        err_loc = err_loc[::-1]\n        #err_eval = rs_find_error_evaluator(synd[::-1], err_loc[::-1], len(err_loc)-1)[::-1] # find error/errata evaluator polynomial (not really necessary since we already compute it at the same time as the error locator poly in BM)\n\n    # locate the message errors\n    err_pos = rs_find_errors(err_loc, len(msg_out), generator) # find the roots of the errata locator polynomial (ie: the positions of the errors/errata)\n    if err_pos is None:\n        raise ReedSolomonError("Could not locate error")\n\n    # compute errata evaluator and errata magnitude polynomials, then correct errors and erasures\n    msg_out = rs_correct_errata(msg_out, synd, err_pos, fcr=fcr, generator=generator)\n    # check if the final message is fully repaired\n    synd = rs_calc_syndromes(msg_out, nsym, fcr, generator)\n    if max(synd) > 0:\n        raise ReedSolomonError("Could not correct message")\n    # return the successfully decoded message\n    return msg_out[:-nsym], msg_out[-nsym:], erase_pos + err_pos # also return the corrected ecc block so that the user can check(), and the position of errors to allow for adaptive bitrate algorithm to check how the number of errors vary\n\ndef rs_check(msg, nsym, fcr=0, generator=2):\n    \'\'\'Returns true if the message + ecc has no error of false otherwise (may not always catch a wrong decoding or a wrong message, particularly if there are too many errors -- above the Singleton bound --, but it usually does)\'\'\'\n    return ( max(rs_calc_syndromes(msg, nsym, fcr, generator)) == 0 )\n\n\n#===================================================================================================\n# API\n#===================================================================================================\nclass RSCodec(object):\n    \'\'\'\n    A Reed Solomon encoder/decoder. After initializing the object, use ``encode`` to encode a\n    (byte)string to include the RS correction code, and pass such an encoded (byte)string to\n    ``decode`` to extract the original message (if the number of errors allows for correct decoding).\n    The ``nsym`` argument is the length of the correction code, and it determines the number of\n    error bytes (if I understand this correctly, half of ``nsym`` is correctable)\n    \'\'\'\n    \'\'\'\n    Modifications by rotorgit 2/3/2015:\n    Added support for US FAA ADSB UAT RS FEC, by allowing user to specify\n    different primitive polynomial and non-zero first consecutive root (fcr).\n    For UAT/ADSB use, set fcr=120 and prim=0x187 when instantiating\n    the class; leaving them out will default for previous values (0 and\n    0x11d)\n    \'\'\'\n\n    def __init__(self, nsym=10, nsize=255, fcr=0, prim=0x11d, generator=2, c_exp=8, single_gen=True):\n        \'\'\'Initialize the Reed-Solomon codec. Note that different parameters change the internal values (the ecc symbols, look-up table values, etc) but not the output result (whether your message can be repaired or not, there is no influence of the parameters).\n        nsym : number of ecc symbols (you can repair nsym/2 errors and nsym erasures.\n        nsize : maximum length of each chunk. If higher than 255, will use a higher Galois Field, but the algorithm\'s complexity and computational cost will raise quadratically...\n        single_gen : if you want to use the same RSCodec for different nsym parameters (but nsize the same), then set single_gen = False.\n        \'\'\'\n\n        # Auto-setup if galois field or message length is different than default (exponent 8)\n        if nsize > 255 and c_exp <= 8:  # nsize (chunksize) is larger than the galois field, we resize the galois field\n            # Get the next closest power of two\n            c_exp = int(math.log(2 ** (math.floor(math.log(nsize) / math.log(2)) + 1), 2))\n        if c_exp != 8 and prim == 0x11d:  # prim was not correctly defined, find one\n            prim = find_prime_polys(generator=generator, c_exp=c_exp, fast_primes=True, single=True)\n            if nsize == 255:  # resize chunk size if not set\n                nsize = int(2**c_exp - 1)\n        if nsym >= nsize:\n            raise ValueError(\'ECC symbols must be strictly less than the total message length (nsym < nsize).\')\n\n        # Memorize variables\n        self.nsym = nsym # number of ecc symbols (ie, the repairing rate will be r=(nsym/2)/nsize, so for example if you have nsym=5 and nsize=10, you have a rate r=0.25, so you can correct up to 0.25% errors (or exactly 2 symbols out of 10), and 0.5% erasures (5 symbols out of 10).\n        self.nsize = nsize # maximum length of one chunk (ie, message + ecc symbols after encoding, for the message alone it\'s nsize-nsym)\n        self.fcr = fcr # first consecutive root, can be any value between 0 and (2**c_exp)-1\n        self.prim = prim # prime irreducible polynomial, use find_prime_polys() to find a prime poly\n        self.generator = generator # generator integer, must be prime\n        self.c_exp = c_exp # exponent of the field\'s characteristic. This both defines the maximum value per symbol and the maximum length of one chunk. By default it\'s GF(2^8), do not change if you\'re not sure what it means.\n\n        # Initialize the look-up tables for easy and quick multiplication/division\n        self.gf_log, self.gf_exp, self.field_charac = init_tables(prim, generator, c_exp)\n        # Precompute the generator polynomials\n        if single_gen:\n            self.gen = {}\n            self.gen[nsym] = rs_generator_poly(nsym, fcr=fcr, generator=generator)\n        else:\n            self.gen = rs_generator_poly_all(nsize, fcr=fcr, generator=generator)\n\n    def chunk(self, data, chunksize):\n        \'\'\'Split a long message into chunks\'\'\'\n        for i in xrange(0, len(data), chunksize):\n            # Split the long message in a chunk\n            chunk = data[i:i+chunksize]\n            yield chunk\n\n    def encode(self, data, nsym=None):\n        \'\'\'Encode a message (ie, add the ecc symbols) using Reed-Solomon, whatever the length of the message because we use chunking\'\'\'\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        enc = _bytearray()\n        for chunk in self.chunk(data, self.nsize - self.nsym):\n            enc.extend(rs_encode_msg(chunk, self.nsym, fcr=self.fcr, generator=self.generator, gen=self.gen[nsym]))\n        return enc\n\n    def decode(self, data, nsym=None, erase_pos=None, only_erasures=False):\n        \'\'\'Repair a message, whatever its size is, by using chunking. May return a wrong result if number of errors > nsym.\n        Note that it returns a couple of vars: the repaired messages, and the repaired messages+ecc (useful for checking).\n        Usage: rmes, rmesecc = RSCodec.decode(data).\n        \'\'\'\n        # erase_pos is a list of positions where you know (or greatly suspect at least) there is an erasure (ie, wrong character but you know it\'s at this position). Just input the list of all positions you know there are errors, and this method will automatically split the erasures positions to attach to the corresponding data chunk.\n\n        # Restore precomputed tables (allow to use multiple RSCodec in one script)\n        global gf_log, gf_exp, field_charac\n        gf_log, gf_exp, field_charac = self.gf_log, self.gf_exp, self.field_charac\n\n        if not nsym:\n            nsym = self.nsym\n\n        if isinstance(data, str):\n            data = _bytearray(data)\n        dec = _bytearray()\n        dec_full = _bytearray()\n        errata_pos_all = _bytearray()\n        for chunk in self.chunk(data, self.nsize):\n            # Extract the erasures for this chunk\n            e_pos = []\n            if erase_pos:\n                # First extract the erasures for this chunk (all erasures below the maximum chunk length)\n                e_pos = [x for x in erase_pos if x < self.nsize]\n                # Then remove the extract erasures from the big list and also decrement all subsequent positions values by nsize (the current chunk\'s size) so as to prepare the correct alignment for the next iteration\n                erase_pos = [x - self.nsize for x in erase_pos if x >= self.nsize]\n            # Decode/repair this chunk!\n            rmes, recc, errata_pos = rs_correct_msg(chunk, nsym, fcr=self.fcr, generator=self.generator, erase_pos=e_pos, only_erasures=only_erasures)\n            dec.extend(rmes)\n            dec_full.extend(rmes+recc)\n            errata_pos_all.extend(errata_pos)\n        return dec, dec_full, errata_pos_all\n\n    def check(self, data, nsym=None):\n        \'\'\'Check if a message+ecc stream is not corrupted (or fully repaired). Note: may return a wrong result if number of errors > nsym.\'\'\'\n        if not nsym:\n            nsym = self.nsym\n        if isinstance(data, str):\n            data = _bytearray(data)\n        check = []\n        for chunk in self.chunk(data, self.nsize):\n            check.append(rs_check(chunk, nsym, fcr=self.fcr, generator=self.generator))\n        return check\n\n    def maxerrata(self, errors=None, erasures=None, verbose=False):\n        \'\'\'Return the Singleton Bound for the current codec, which is the max number of errata (errors and erasures) that the codec can decode/correct.\n        Beyond the Singleton Bound (too many errors/erasures), the algorithm will try to raise an exception, but it may also not detect any problem with the message and return 0 errors.\n        Hence why you should use checksums if your goal is to detect errors (as opposed to correcting them), as checksums have no bounds on the number of errors, the only limitation being the probability of collisions.\n        By default, return a tuple wth the maximum number of errors (2nd output) OR erasures (2nd output) that can be corrected.\n        If errors or erasures (not both) is specified as argument, computes the remaining **simultaneous** correction capacity (eg, if errors specified, compute the number of erasures that can be simultaneously corrected).\n        Set verbose to True to get print a report.\'\'\'\n        nsym = self.nsym\n        # Compute the maximum number of errors OR erasures\n        maxerrors = int(nsym/2)  # always floor the number, we can\'t correct half a symbol, it\'s all or nothing\n        maxerasures = nsym\n        # Compute the maximum of simultaneous errors AND erasures\n        if erasures is not None and erasures >= 0:\n            # We know the erasures count, we want to know how many errors we can correct simultaneously\n            if erasures > maxerasures:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerrors = int((nsym-erasures)/2)\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (maxerrors, erasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return maxerrors, erasures\n        if errors is not None and errors >= 0:\n            # We know the errors count, we want to know how many erasures we can correct simultaneously\n            if errors > maxerrors:\n                raise ReedSolomonError("Specified number of errors or erasures exceeding the Singleton Bound!")\n            maxerasures = int(nsym-(errors*2))\n            if verbose:\n                print(\'This codec can correct up to %i errors and %i erasures simultaneously\' % (errors, maxerasures))\n            # Return a tuple with the maximum number of simultaneously corrected errors and erasures\n            return errors, maxerasures\n        # Return a tuple with the maximum number of errors and erasures (independently corrected)\n        if verbose:\n            print(\'This codec can correct up to %i errors and %i erasures independently\' % (maxerrors, maxerasures))\n        return maxerrors, maxerasures\n'
      _rs_module = _types.ModuleType('_grc_embedded_reedsolo_170')
      exec(compile(_REEDSOLO_SOURCE, '<embedded reedsolo 1.7.0>', 'exec'), _rs_module.__dict__)
      RSCodec = _rs_module.RSCodec
      ReedSolomonError = _rs_module.ReedSolomonError
      del _REEDSOLO_SOURCE


      class blk(gr.basic_block):
          """Encode all packet types (DATA, metadata, ACK and other controls)."""
          def __init__(self, nsym=16, enabled=True, verbose=True, log_every=50):
              gr.basic_block.__init__(self, name='RS Packet Encoder',
                                      in_sig=None, out_sig=None)
              self.nsym = int(nsym)
              if not 2 <= self.nsym <= 128 or self.nsym % 2:
                  raise ValueError('nsym must be even, between 2 and 128')
              self.k = 255 - self.nsym
              self.enabled, self.verbose = bool(enabled), bool(verbose)
              self.log_every = max(1, int(log_every))
              self.max_input = 4096  # Existing 4092-byte encrypted PDU budget + CRC32.
              self.rs = RSCodec(self.nsym, nsize=255, fcr=0,
                                prim=0x11d, generator=2, c_exp=8)
              self.tx_count = self.reject_count = 0
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: expected a packed-byte PDU', flush=True)
                  return
              raw = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              if not 4 <= len(raw) <= self.max_input:
                  self.reject_count += 1
                  if self.verbose:
                      print('[RS TX] DROP: packet must be 4..4096 bytes including CRC', flush=True)
                  return
              if self.enabled:
                  # Explicit boundaries prevent accidental changes to chunking conventions.
                  chunks = [bytes(self.rs.encode(raw[i:i+self.k]))
                            for i in range(0, len(raw), self.k)]
                  encoded = b''.join(chunks)
                  nwords = len(chunks)
              else:
                  encoded, nwords = raw, 0
              meta = pmt.car(msg)
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern('packet_len')):
                  meta = pmt.dict_add(meta, pmt.intern('packet_len'), pmt.from_long(len(encoded)))
              out = pmt.cons(meta, pmt.init_u8vector(len(encoded), list(encoded)))
              self.message_port_pub(pmt.intern('pdu_out'), out)
              self.tx_count += 1
              if self.verbose and (self.tx_count == 1 or self.tx_count % self.log_every == 0):
                  print(f'[RS TX #{self.tx_count}] {len(raw)} -> {len(encoded)} bytes; '
                        f'codewords={nwords}; FEC={self.enabled}', flush=True)

          def stop(self):
              if self.verbose:
                  print(f'[RS TX SUMMARY] packets={self.tx_count}; rejected={self.reject_count}', flush=True)
              return True
    comment: Self-contained RS FEC; no external reedsolo install. Packed-byte PDUs; both peers need matching nsym.
    enabled: fec_enabled
    log_every: fec_log_every
    nsym: fec_nsym
    verbose: fec_verbose
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: game_client_1
  id: epy_block
  parameters:
    _source_code: |
      """Among Us Lite v2 node (host = node_id 0, clients = 1..n-1) for the QPSK GNU Radio link.
      Ports: rx_in (PDU from CRC Check 'ok'), tx_out (PDU to CRC Append).
      Wire format (all small): 5-byte header (magic|type, sender, dest, seq16) + payload (keystream-XOR) + 4-byte MAC.
      STATE (host->all, every tick) carries the whole world; INPUT (client->host) is sent in the client's own time slot.
      Events (use/kill/report/vent/sabotage/ability/chat) repeat until the host echoes their id, so no ACK packets are needed.
      v2: up to 16 players, 2 maps (random per round), 14+ tasks incl. multi-step ones, vents, sabotage (lights/reactor),
      fog of war, security/admin reveal, 2 impostors for 7+ players, roles: Crew, Impostor, Engineer, Scientist, Guardian.
      Keys: WASD/arrows move | E use | K kill | R report/button | Z lights-sabotage | X reactor-sabotage | V vent | F ability | 1-9 vote.
      """
      import hashlib, hmac, random, struct, threading, time
      from collections import deque
      from gnuradio import gr
      import pmt


      # ---------------- maps (built from rooms + corridors, identical on every node) ----------------
      class GMap:
          def __init__(s, name, W, H, rooms, cors, st):
              s.name, s.W, s.H = name, W, H
              s.g = [['#'] * W for _ in range(H)]
              s.rooms, s.col = [], [[-1] * W for _ in range(H)]
              for k, (nm, x0, y0, x1, y1) in enumerate(rooms):
                  s.rooms.append((nm, x0, y0, x1, y1))
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          s.g[y][x], s.col[y][x] = '.', k
              for x0, y0, x1, y1 in cors:
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          if s.g[y][x] == '#':
                              s.g[y][x] = '.'
              for ch, pts in st.items():
                  for x, y in pts:
                      assert s.g[y][x] == '.', (name, ch, x, y)
                      s.g[y][x] = ch
              s.rows = [''.join(r) for r in s.g]
              s.tasks = [(x, y, s.g[y][x]) for y in range(H) for x in range(W) if s.g[y][x] in 'TDF']
              assert len(s.tasks) <= 16
              s.tpos = {(x, y): k for k, (x, y, c) in enumerate(s.tasks)}
              s.button = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'V'][0]
              s.panels = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'R']
              s.vgroups, s.vent = {}, {}
              for ch in 'abcdef':
                  pts = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == ch]
                  if pts:
                      s.vgroups[ch] = pts
                      for i, p in enumerate(pts):
                          s.vent[p] = pts[(i + 1) % len(pts)]
              bx, by = s.button
              fl = [(abs(x - bx) + abs(y - by), x, y) for y in range(H) for x in range(W) if s.g[y][x] == '.']
              s.spawns = [(x, y) for _, x, y in sorted(fl)[:24]]

          def at(s, x, y):
              return s.g[y][x] if 0 <= x < s.W and 0 <= y < s.H else '#'

          def free(s, x, y):
              return s.at(x, y) != '#'

          def room(s, x, y):
              for nm, x0, y0, x1, y1 in s.rooms:
                  if x0 <= x <= x1 and y0 <= y <= y1:
                      return nm
              return 'hall'


      MAPS = [
          GMap('Skeld Lite', 44, 24,
               [('Upper Engine', 2, 1, 10, 6), ('Cafeteria', 15, 1, 28, 6), ('Weapons', 33, 1, 41, 6),
                ('Medbay', 2, 9, 10, 14), ('Admin', 15, 9, 21, 14), ('Storage', 23, 9, 28, 14), ('Navigation', 33, 9, 41, 14),
                ('Electrical', 2, 17, 10, 22), ('Reactor', 15, 17, 21, 22), ('Security', 23, 17, 28, 22), ('O2 / Shields', 33, 17, 41, 22)],
               [(11, 3, 14, 3), (29, 3, 32, 3), (11, 11, 14, 11), (29, 11, 32, 11), (22, 11, 22, 11), (11, 19, 14, 19),
                (29, 19, 32, 19), (22, 19, 22, 19), (5, 7, 5, 8), (18, 7, 18, 8), (25, 7, 25, 8), (37, 7, 37, 8),
                (5, 15, 5, 16), (18, 15, 18, 16), (25, 15, 25, 16), (37, 15, 37, 16)],
               {'V': [(21, 3)], 'T': [(17, 5), (26, 2), (4, 10), (20, 13), (35, 2), (35, 10), (4, 18), (35, 18), (26, 20), (16, 12)],
                'D': [(4, 2), (39, 5), (25, 10), (39, 20)], 'F': [(39, 13), (9, 21)], 'G': [(26, 13), (9, 18)],
                'R': [(16, 18), (3, 3)], 'L': [(8, 18)], 'A': [(17, 10)], 'Q': [(25, 19)],
                'a': [(9, 5), (3, 13), (3, 21)], 'b': [(27, 5), (40, 2), (40, 10)], 'c': [(16, 14), (27, 10), (20, 21)],
                'd': [(27, 22), (34, 21), (34, 5)]}),
          GMap('Outpost', 36, 20,
               [('Lab', 1, 1, 10, 5), ('Hangar', 25, 1, 34, 5), ('Armory', 1, 7, 8, 12), ('Hub', 13, 7, 22, 12),
                ('Comms', 27, 7, 34, 12), ('Quarters', 1, 14, 10, 18), ('Engine', 25, 14, 34, 18)],
               [(11, 3, 24, 3), (17, 4, 17, 6), (9, 9, 12, 9), (23, 9, 26, 9), (4, 6, 4, 6), (30, 6, 30, 6), (4, 13, 4, 13),
                (30, 13, 30, 13), (17, 13, 17, 16), (11, 16, 24, 16)],
               {'V': [(17, 9)], 'T': [(2, 8), (14, 8), (28, 8), (6, 15), (33, 3), (27, 16), (8, 3), (21, 11), (33, 11), (2, 17)],
                'D': [(7, 11), (26, 2), (9, 17), (31, 17)], 'F': [(33, 17), (5, 2)], 'G': [(2, 12), (28, 11)],
                'R': [(26, 15), (2, 2)], 'L': [(3, 15)], 'A': [(20, 8)], 'Q': [(32, 8)],
                'a': [(9, 5), (3, 9), (9, 15)], 'b': [(34, 5), (34, 12), (26, 17)], 'c': [(14, 11), (21, 8)]})
      ]

      DIRS = {1: (0, -1), 2: (0, 1), 3: (-1, 0), 4: (1, 0)}
      LOBBY, PLAY, MEET, END = 0, 1, 2, 3
      CREW, IMP, ENG, SCI, GRD = 0, 1, 2, 3, 4
      ROLE_NAME = {CREW: 'CREW', IMP: 'IMPOSTOR', ENG: 'ENGINEER', SCI: 'SCIENTIST', GRD: 'GUARDIAN'}
      ROLE_HELP = {CREW: 'do tasks (E)', IMP: 'kill K, vent V, sabotage Z/X', ENG: 'tasks + vent V (3 hops) + F = remote sabotage fix (1x)',
                   SCI: 'tasks + vitals: you see who is dead', GRD: 'tasks + F = shield nearest player (blocks 1 kill)'}
      T_STATE, T_INPUT, T_ROLE = 1, 2, 3
      BCAST, MAGIC, SKIP = 255, 0xA0, 0xFE
      MAXP = 16
      TASK_NAME = {'T': 'Wiring', 'D': 'Download (E x3, stay)', 'F': 'Fuel engine (take gas G first)'}


      def bfs_dir(mp, src, dst):
          if src == dst:
              return 0
          q, seen = deque([(src, 0)]), {src}
          while q:
              (x, y), first = q.popleft()
              for d, (dx, dy) in DIRS.items():
                  n = (x + dx, y + dy)
                  if n in seen or not mp.free(*n):
                      continue
                  if n == dst:
                      return first or d
                  seen.add(n)
                  q.append((n, first or d))
          return 0


      # ---------------- security / framing ----------------
      def _ks(key, hdr, n):
          out, c = b'', 0
          while len(out) < n:
              out += hashlib.sha256(key + hdr + bytes([c])).digest()
              c += 1
          return out[:n]


      def seal(key, typ, sender, dest, seq, payload):
          hdr = bytes([MAGIC | typ, sender, dest]) + struct.pack('!H', seq & 0xFFFF)
          ct = bytes(a ^ b for a, b in zip(payload, _ks(key, hdr, len(payload))))
          return hdr + ct + hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4]


      def unseal(key, raw):
          if len(raw) < 9 or (raw[0] & 0xF0) != MAGIC:
              return None
          hdr, ct, mac = raw[:5], raw[5:-4], raw[-4:]
          if not hmac.compare_digest(hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4], mac):
              return None
          pt = bytes(a ^ b for a, b in zip(ct, _ks(key, hdr, len(ct))))
          return hdr[0] & 0x0F, hdr[1], hdr[2], struct.unpack('!H', hdr[3:5])[0], pt


      def newer(seq, last):
          return last is None or 0 < ((seq - last) & 0xFFFF) < 0x8000


      # ---------------- authoritative game core (host only) ----------------
      class Core:
          def __init__(s, n, rng=None, kill_cd=8.0, meet_s=15.0, sab_cd=20.0, react_s=30.0, map_pref=0):
              s.n, s.rng, s.kill_cd, s.meet_s = n, rng or random.Random(), kill_cd, meet_s
              s.sab_cd, s.react_s, s.map_pref = sab_cd, react_s, map_pref
              s.mapid = 0
              s.lobby()

          @property
          def mp(s):
              return MAPS[s.mapid]

          def lobby(s):
              n = s.n
              s.phase, s.winner, s.done, s.active, s.eject = LOBBY, 0, 0, 0, 255
              s.imps, s.role = set(), [-1] * n
              s.inplay, s.alive, s.body = [0] * n, [1] * n, [0] * n
              s.dir, s.vote = [0] * n, [0] * n
              s.sp = list(s.mp.spawns)
              s.pos = [s.spawn(i) for i in range(n)]
              s.meet_end = s.sab_ready = 0
              s.kill_ready = [0.0] * n
              s.dl, s.fuel, s.shield = [[-1, 0] for _ in range(n)], [0] * n, [0] * n
              s.ventl, s.engfix, s.btn = [0] * n, [0] * n, [0] * n
              s.lights, s.react_end, s.rpanel = 0, 0.0, {}

          def spawn(s, i):
              return s.sp[i % len(s.sp)]

          def start(s, now, present):
              ids = [i for i in range(s.n) if present[i]]
              if len(ids) < 3:
                  return False
              s.lobby()
              mid = s.map_pref - 1 if 1 <= s.map_pref <= len(MAPS) else s.rng.randrange(len(MAPS))
              s.mapid = mid
              s.sp = list(s.mp.spawns)
              s.rng.shuffle(s.sp)
              s.pos = [s.spawn(i) for i in range(s.n)]
              s.phase = PLAY
              for i in ids:
                  s.inplay[i] = 1
              s.alive = [1 if s.inplay[i] else 0 for i in range(s.n)]
              order = ids[:]
              s.rng.shuffle(order)
              ni = 2 if len(ids) >= 7 else 1
              s.imps = set(order[:ni])
              crew = order[ni:]
              for i in ids:
                  s.role[i] = IMP if i in s.imps else CREW
              for r, need in ((ENG, 4), (SCI, 5), (GRD, 6)):
                  if len(ids) >= need and crew:
                      s.role[crew.pop()] = r
              for i in ids:
                  if s.role[i] == ENG:
                      s.ventl[i], s.engfix[i] = 3, 1
                  if i in s.imps:
                      s.kill_ready[i] = now + s.kill_cd
              ncrew = len(ids) - ni
              k = min(len(s.mp.tasks), max(5, 2 * ncrew + 2))
              for t in s.rng.sample(range(len(s.mp.tasks)), k):
                  s.active |= 1 << t
              s.sab_ready = now + s.sab_cd
              return True

          def end(s, w):
              s.phase, s.winner = END, w

          def check(s):
              crew = [i for i in range(s.n) if s.inplay[i] and s.alive[i] and i not in s.imps]
              imps = [i for i in s.imps if s.alive[i]]
              if not imps:
                  s.end(1)
              elif len(crew) <= len(imps):
                  s.end(2)

          def step(s, now):
              if s.phase == PLAY:
                  for i in range(s.n):
                      if s.inplay[i] and s.alive[i] and s.dir[i] in DIRS:
                          dx, dy = DIRS[s.dir[i]]
                          x, y = s.pos[i]
                          if s.mp.free(x + dx, y + dy):
                              s.pos[i] = (x + dx, y + dy)
                      t = s.dl[i][0]
                      if t >= 0 and s.pos[i] != s.mp.tasks[t][:2]:
                          s.dl[i] = [-1, 0]
                  if s.react_end and now >= s.react_end:
                      s.end(2)
              elif s.phase == MEET:
                  voters = [i for i in range(s.n) if s.inplay[i] and s.alive[i]]
                  if now >= s.meet_end or all(s.vote[i] for i in voters):
                      s.tally(now)

          def _use(s, p, x, y, now):
              mp, ch = s.mp, s.mp.at(x, y)
              if ch in 'TDF' and (x, y) in mp.tpos:
                  k = mp.tpos[(x, y)]
                  if not (s.active >> k & 1) or (s.done >> k & 1):
                      return
                  ok = False
                  if ch == 'T':
                      ok = True
                  elif ch == 'D':
                      s.dl[p] = [k, s.dl[p][1] + 1] if s.dl[p][0] == k else [k, 1]
                      if s.dl[p][1] >= 3:
                          ok, s.dl[p] = True, [-1, 0]
                  elif ch == 'F' and s.fuel[p]:
                      ok, s.fuel[p] = True, 0
                  if ok:
                      s.done |= 1 << k
                      if s.done & s.active == s.active:
                          s.end(1)
              elif ch == 'G':
                  s.fuel[p] = 1
              elif ch == 'L' and s.lights:
                  s.lights = 0
              elif ch == 'R' and s.react_end:
                  s.rpanel[(x, y)] = now
                  if all(now - s.rpanel.get(q, -99) <= 4.0 for q in mp.panels):
                      s.react_end, s.rpanel = 0.0, {}

          def act(s, p, a, now):
              if s.phase != PLAY or not s.inplay[p] or not s.alive[p]:
                  return
              x, y = s.pos[p]
              imp, role = p in s.imps, s.role[p]
              if a & 1 and not imp:
                  s._use(p, x, y, now)
                  if s.phase != PLAY:
                      return
              if a & 2 and imp and now >= s.kill_ready[p]:
                  best = None
                  for q in range(s.n):
                      if q != p and s.inplay[q] and s.alive[q] and q not in s.imps:
                          d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                          if d <= 2 and (best is None or d < best[0]):
                              best = (d, q)
                  if best:
                      q = best[1]
                      if s.shield[q]:
                          s.shield[q], s.kill_ready[p] = 0, now + 4.0
                      else:
                          s.alive[q], s.body[q], s.kill_ready[p] = 0, 1, now + s.kill_cd
                          s.check()
                          if s.phase != PLAY:
                              return
              if a & 4:
                  near = any(s.body[q] and abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y) <= 2 for q in range(s.n))
                  btn = (x, y) == s.mp.button and not s.btn[p] and not s.react_end
                  if near or btn:
                      if not near:
                          s.btn[p] = 1
                      s.phase, s.meet_end, s.vote, s.eject = MEET, now + s.meet_s, [0] * s.n, 255
                      s.body, s.dir = [0] * s.n, [0] * s.n
                      s.pos = [s.spawn(i) for i in range(s.n)]
                      s.dl = [[-1, 0] for _ in range(s.n)]
                      return
              if a & 8 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.lights, s.sab_ready = 1, now + s.sab_cd
              if a & 0x40 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.react_end, s.rpanel, s.sab_ready = now + s.react_s, {}, now + s.sab_cd + s.react_s
              if a & 16 and (imp or (role == ENG and s.ventl[p] > 0)) and (x, y) in s.mp.vent:
                  s.pos[p] = s.mp.vent[(x, y)]
                  if not imp:
                      s.ventl[p] -= 1
              if a & 32:
                  if role == ENG and s.engfix[p] > 0 and (s.lights or s.react_end):
                      s.lights, s.react_end, s.rpanel, s.engfix[p] = 0, 0.0, {}, 0
                  elif role == GRD:
                      best = None
                      for q in range(s.n):
                          if q != p and s.inplay[q] and s.alive[q]:
                              d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                              if d <= 3 and (best is None or d < best[0]):
                                  best = (d, q)
                      if best:
                          s.shield = [0] * s.n
                          s.shield[best[1]] = 1

          def set_vote(s, p, v):
              if s.phase == MEET and s.inplay[p] and s.alive[p]:
                  if v == SKIP or (1 <= v <= s.n and s.inplay[v - 1] and s.alive[v - 1]):
                      s.vote[p] = v

          def tally(s, now):
              cnt = {}
              for i in range(s.n):
                  if s.inplay[i] and s.alive[i] and s.vote[i]:
                      cnt[s.vote[i]] = cnt.get(s.vote[i], 0) + 1
              top = sorted(cnt.items(), key=lambda kv: -kv[1])
              s.eject = 254
              if top and (len(top) == 1 or top[0][1] > top[1][1]) and top[0][0] != SKIP:
                  q = top[0][0] - 1
                  s.alive[q], s.eject = 0, q
                  s.check()
                  if s.phase == END:
                      return
              s.phase, s.vote, s.dir = PLAY, [0] * s.n, [0] * s.n
              for i in s.imps:
                  s.kill_ready[i] = now + s.kill_cd
              s.sab_ready = now + s.sab_cd
              s.lights, s.react_end, s.rpanel, s.shield = 0, 0.0, {}, [0] * s.n
              s.pos = [s.spawn(i) for i in range(s.n)]

          def view(s, present, now, acks):
              pl = []
              for i in range(s.n):
                  fl = s.alive[i] | ((1 if (s.inplay[i] or present[i]) else 0) << 1) | (s.body[i] << 2) | ((1 if s.vote[i] else 0) << 3)
                  aux = (s.dl[i][1] & 3) | (s.fuel[i] << 2) | (s.shield[i] << 3) | ((s.ventl[i] & 3) << 4) | ((1 if s.engfix[i] else 0) << 6)
                  pl.append((s.pos[i][0], s.pos[i][1], fl, acks[0][i], acks[1][i], aux))
              kl = [s.kill_ready[i] - now for i in s.imps if s.alive[i]]
              mask = sum(1 << i for i in s.imps) if s.phase == END else 0
              return dict(phase=s.phase, winner=s.winner, done=s.done, active=s.active,
                          meet_left=int(max(0, s.meet_end - now)) if s.phase == MEET else 0,
                          n=s.n, mapid=s.mapid, reveal=mask, eject=s.eject,
                          flags=(1 if s.lights else 0) | (2 if s.react_end else 0),
                          sab_left=int(max(0, s.react_end - now)) if s.react_end else 0,
                          sab_cd=int(min(255, max(0, s.sab_ready - now))) if s.phase == PLAY else 0,
                          kill_left=int(min(255, max(0, min(kl)))) if (kl and s.phase == PLAY) else 0, players=pl)


      HDR = '!BBHHBBBHBBBBBBBB'


      def pack_state(v, chat):
          cid, cfrom, ctext = chat
          out = struct.pack(HDR, v['phase'], v['winner'], v['done'], v['active'], v['meet_left'], v['n'], v['mapid'],
                            v['reveal'], v['eject'], v['flags'], v['sab_left'], v['sab_cd'], v['kill_left'], cid, cfrom, len(ctext)) + ctext
          for x, y, fl, ca, ha, ax in v['players']:
              out += struct.pack('!BBBBBB', x, y, fl, ca, ha, ax)
          return out


      def unpack_state(pt):
          hs = struct.calcsize(HDR)
          ph, win, dn, ac, ml, n, mid, rev, ej, fg, sl, sc, kl, cid, cf, cl = struct.unpack(HDR, pt[:hs])
          text, o, pl = pt[hs:hs + cl], hs + cl, []
          for i in range(n):
              pl.append(struct.unpack('!BBBBBB', pt[o + 6 * i:o + 6 * i + 6]))
          return dict(phase=ph, winner=win, done=dn, active=ac, meet_left=ml, n=n, mapid=mid, reveal=rev, eject=ej, flags=fg,
                      sab_left=sl, sab_cd=sc, kill_left=kl, players=pl), (cid, cf, text)


      # ---------------- GNU Radio block ----------------
      class blk(gr.basic_block):
          def __init__(self, node_id=0, n_players=4, tick_ms=250, slot_ms=45, guard_ms=70,
                       key='change-this-game-key', show_gui=1, bot=0, min_players=3, title='Among Us Lite', map_pref=0):
              gr.basic_block.__init__(self, name="Among Us Lite Node", in_sig=None, out_sig=None)
              self.me, self.n = int(node_id), min(MAXP, max(3, int(n_players)))
              self.host = self.me == 0
              # TDMA frame must fit every client slot: stretch the tick automatically for big lobbies (same maths on every node)
              tick_ms = max(float(tick_ms), float(guard_ms) + (self.n - 1) * float(slot_ms) + 30.0)
              self.tick, self.slot, self.guard = tick_ms / 1000.0, slot_ms / 1000.0, guard_ms / 1000.0
              self.key = str(key).encode()
              self.show_gui, self.bot, self.title = bool(show_gui), bool(bot), str(title)
              self.map_pref = int(map_pref)
              self.lk = threading.RLock()
              self.running, self.seq, self.win = False, 0, None
              self.dirv, self.pending, self.myvote, self.start_req = 0, 0, 0, False
              self.chat_log, self.chat_out, self.cur_chat, self.last_chat_id = [], deque(), (0, b''), 0
              self.role, self.partners, self.view, self.t_state, self.prev, self.rng = None, 0, None, 0.0, {}, random.Random()
              self.cmd_id, self.bot_t, self.fail = 0, 0, 0
              if self.host:
                  self.core, self.last_rx = Core(self.n, map_pref=self.map_pref), [0.0] * self.n
                  self.cmd_seen, self.chat_seen, self.roleack = [0] * self.n, [0] * self.n, [0] * self.n
                  self.seq_in, self.hchat, self.chat_id, self.chat_cur, self.rr = [None] * self.n, deque(), 0, (0, 0, b''), 0
              else:
                  self.last_state_seq = None
              self._bridge = None
              if self.show_gui:
                  try:  # object created on the main (Qt) thread; its signal is queued to that thread
                      from PyQt5 import QtCore
                      if QtCore.QCoreApplication.instance() is not None:
                          class _Bridge(QtCore.QObject):
                              go = QtCore.pyqtSignal()
                          self._bridge = _Bridge()
                          self._bridge.go.connect(self._build_gui_safe)
                  except Exception as e:
                      print("game GUI bridge unavailable:", e)
              self.message_port_register_in(pmt.intern("rx_in"))
              self.message_port_register_out(pmt.intern("tx_out"))
              self.set_msg_handler(pmt.intern("rx_in"), self.handle_rx)

          # ---- lifecycle ----
          def start(self):
              self.running = True
              if self.host:
                  threading.Thread(target=self._host_loop, daemon=True).start()
              if self.show_gui:
                  if self._bridge is not None:
                      self._bridge.go.emit()
                  else:
                      self._build_gui_safe()
              return True

          def _build_gui_safe(self):
              try:
                  self._build_gui()
              except Exception as e:
                  print("game GUI disabled:", repr(e))

          def stop(self):
              self.running = False
              return True

          # ---- radio I/O ----
          def _send(self, typ, dest, payload):
              self.seq = (self.seq + 1) & 0xFFFF
              raw = seal(self.key, typ, self.me, dest, self.seq, payload)
              self.message_port_pub(pmt.intern("tx_out"), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def handle_rx(self, msg):
              try:
                  if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                      return
                  r = unseal(self.key, bytes(pmt.u8vector_elements(pmt.cdr(msg))))
                  if r is None:
                      self.fail += 1
                      return
                  typ, snd, dst, seq, pt = r
                  now = time.time()
                  if snd == self.me:
                      return
                  with self.lk:
                      if self.host and typ == T_INPUT and 0 < snd < self.n and dst == 0:
                          if newer(seq, self.seq_in[snd]):
                              self.seq_in[snd] = seq
                              self._on_input(snd, pt, now)
                      elif (not self.host) and snd == 0 and dst in (BCAST, self.me):
                          if typ == T_STATE and newer(seq, self.last_state_seq):
                              self.last_state_seq = seq
                              self._on_state(pt, now)
                          elif typ == T_ROLE and dst == self.me:
                              self.role = pt[0]
                              self.partners = struct.unpack('!H', pt[1:3])[0] if len(pt) >= 3 else 0
              except Exception as e:
                  print("game rx error:", repr(e))

          # ---- host ----
          def _on_input(self, p, pt, now):
              c = self.core
              d, cmd, act, vote, cid, cl = struct.unpack('!BBBBBB', pt[:6])
              text = pt[6:6 + cl]
              self.last_rx[p] = now
              c.dir[p] = d if d in DIRS else 0
              if act & 0x80:
                  self.roleack[p] = 1
              if (act & 0x7F) and cmd != self.cmd_seen[p]:
                  c.act(p, act & 0x7F, now)
              self.cmd_seen[p] = cmd
              c.set_vote(p, vote)
              if cid and cid != self.chat_seen[p]:
                  self.hchat.append((p, text[:20]))
                  self.chat_seen[p] = cid

          def _host_loop(self):
              nxt = time.time()
              while self.running:
                  now = time.time()
                  if now >= nxt:
                      nxt = max(nxt + self.tick, now + self.tick * 0.5)
                      try:
                          self._host_tick(now)
                      except Exception as e:
                          print("host tick error:", repr(e))
                  time.sleep(0.002)

          def _host_tick(self, now):
              with self.lk:
                  c = self.core
                  c.map_pref = self.map_pref
                  present = [1 if (i == 0 or now - self.last_rx[i] < 3.0) else 0 for i in range(self.n)]
                  if self.bot:
                      self._bot(self.view_host(present, now), now, present)
                  if self.start_req:
                      self.start_req = False
                      if c.phase in (LOBBY, END):
                          if c.phase == END:
                              c.lobby()
                          elif c.start(now, present):
                              self.roleack = [1 if i == 0 else 0 for i in range(self.n)]
                              self.role = c.role[0] if c.role[0] >= 0 else None
                              self.partners = sum(1 << i for i in c.imps) if c.role[0] == IMP else 0
                  c.dir[0] = self.dirv
                  if self.pending:
                      c.act(0, self.pending & 0x7F, now)
                      self.pending = 0
                  if c.phase == MEET:
                      c.set_vote(0, self.myvote)
                  for i in range(1, self.n):
                      if not present[i]:
                          c.dir[i] = 0
                  c.step(now)
                  if c.phase != MEET:
                      self.myvote = 0
                  if c.phase == LOBBY:
                      self.role, self.partners = None, 0
                  if self.hchat:
                      self.chat_id = self.chat_id % 255 + 1
                      f, t = self.hchat.popleft()
                      self.chat_cur = (self.chat_id, f, t)
                      self._log(f, t)
                  v = self.view_host(present, now)
                  self._set_view(v, now)
                  self._send(T_STATE, BCAST, pack_state(v, self.chat_cur))
                  if c.phase == PLAY:
                      for k in range(1, self.n):
                          p = 1 + (self.rr + k - 1) % (self.n - 1)
                          if c.inplay[p] and not self.roleack[p]:
                              self.rr = p
                              pm = sum(1 << i for i in c.imps) if p in c.imps else 0
                              self._send(T_ROLE, p, bytes([c.role[p]]) + struct.pack('!H', pm))
                              break

          def view_host(self, present, now):
              return self.core.view(present, now, (self.cmd_seen, self.chat_seen))

          # ---- client ----
          def _on_state(self, pt, now):
              v, chat = unpack_state(pt)
              self._set_view(v, now)
              cid, cf, text = chat
              if cid and cid != self.last_chat_id:
                  self.last_chat_id = cid
                  self._log(cf, text)
              if v['phase'] == LOBBY:
                  self.role, self.partners = None, 0
              if v['phase'] != MEET:
                  self.myvote = 0
              me = v['players'][self.me] if self.me < len(v['players']) else None
              if me:
                  if me[3] == self.cmd_id:
                      self.pending = 0
                  if self.cur_chat[0] and me[4] == self.cur_chat[0]:
                      self.cur_chat = (0, b'')
              if self.bot:
                  self._bot(v, now, None)
              delay = self.guard + (self.me - 1) * self.slot
              t = threading.Timer(delay, self._client_send)
              t.daemon = True
              t.start()

          def _client_send(self):
              if not self.running:
                  return
              with self.lk:
                  if not self.cur_chat[0] and self.chat_out:
                      nid = self.cur_chat_id = (getattr(self, 'cur_chat_id', 0) % 255) + 1
                      self.cur_chat = (nid, self.chat_out.popleft()[:20])
                  cid, ct = self.cur_chat
                  act = (self.pending & 0x7F) | (0x80 if self.role is not None else 0)
                  pl = struct.pack('!BBBBBB', self.dirv, self.cmd_id, act, self.myvote, cid, len(ct)) + ct
              self._send(T_INPUT, 0, pl)

          # ---- shared helpers ----
          def mp(self):
              return MAPS[self.view['mapid'] % len(MAPS)] if self.view else MAPS[0]

          def _set_view(self, v, now):
              old = self.view
              if old and old['mapid'] == v['mapid'] and len(old['players']) == len(v['players']):
                  self.prev = {i: self.display_pos(i, now) for i in range(len(old['players']))}
              else:
                  self.prev = {}
              self.view, self.t_state = v, now

          def display_pos(self, i, now):
              v = self.view
              if not v or i >= len(v['players']):
                  return (0, 0)
              x, y = v['players'][i][0], v['players'][i][1]
              px, py = self.prev.get(i, (x, y))
              if abs(px - x) + abs(py - y) > 3:  # vent hop / meeting respawn: snap
                  return (x, y)
              a = min(1.0, (now - self.t_state) / max(self.tick, 0.01))
              return (px + (x - px) * a, py + (y - py) * a)

          def _log(self, who, text):
              try:
                  s = text.decode('utf-8', 'replace')
              except Exception:
                  s = '?'
              self.chat_log.append("P%d: %s" % (who + 1, s))
              del self.chat_log[:-60]

          def request_action(self, bit):
              with self.lk:
                  if self.host:
                      self.pending = bit
                  elif not self.pending:
                      self.cmd_id = self.cmd_id % 255 + 1
                      self.pending = bit

          def send_chat(self, text):
              t = text.encode('utf-8')[:20]
              with self.lk:
                  if self.host:
                      self.hchat.append((0, t))
                  else:
                      self.chat_out.append(t)

          def cast_vote(self, v):
              with self.lk:
                  self.myvote = v

          def _bot(self, v, now, present):
              if now - self.bot_t < self.tick * 0.9:
                  return
              self.bot_t = now
              ph, me, mp = v['phase'], self.me, self.mp()
              pl = v['players']
              if ph == LOBBY:
                  if self.host and present is not None and sum(present) >= self.min_players_n() and now - self.t0() > 1.5:
                      self.start_req = True
                  return
              if ph == END:
                  if self.host and now - self.t_end(now) > 3:
                      self.start_req = True
                  return
              mypos, alive = (pl[me][0], pl[me][1]), pl[me][2] & 1
              if ph == MEET:
                  if alive and not self.myvote:
                      cands = [i + 1 for i in range(v['n']) if pl[i][2] & 1 and i != me and not (self.partners >> i & 1)]
                      self.cast_vote(self.rng.choice(cands + [SKIP]))
                  return
              self.dirv = 0
              if not alive:
                  return
              dist = lambda a, b: abs(a[0] - b[0]) + abs(a[1] - b[1])
              if self.role == IMP:
                  tg = [(dist(p, mypos), i) for i, p in enumerate(pl)
                        if i != me and p[2] & 1 and p[2] & 2 and not (self.partners >> i & 1)]
                  if v['sab_cd'] == 0 and not v['flags'] and self.rng.random() < 0.03:
                      self.request_action(8 if self.rng.random() < 0.7 else 0x40)
                  if tg:
                      d, i = min(tg)
                      if d <= 2 and self.rng.random() < 0.5:
                          self.request_action(2)
                      self.dirv = bfs_dir(mp, mypos, (pl[i][0], pl[i][1]))
              else:
                  if v['flags'] & 2:
                      tgt = min(mp.panels, key=lambda t: dist(t, mypos))
                      if mypos == tgt:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tgt)
                      return
                  if v['flags'] & 1:
                      lp = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'L'][0]
                      if mypos == lp:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, lp)
                      return
                  todo = [t for k, t in enumerate(mp.tasks) if v['active'] >> k & 1 and not v['done'] >> k & 1]
                  if todo:
                      fuel = pl[me][5] >> 2 & 1
                      if not fuel and any(t[2] == 'F' for t in todo):
                          gs = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'G']
                          todo = [min(gs, key=lambda g: dist(g, mypos)) + ('G',)]
                      else:
                          todo = [t for t in todo if t[2] != 'F' or fuel]
                      tg = min(todo, key=lambda t: dist(t, mypos))
                      if mypos == tg[:2]:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tg[:2])
                  bodies = [dist(p, mypos) for p in pl if p[2] & 4]
                  if bodies and min(bodies) <= 2:
                      self.request_action(4)

          def min_players_n(self):
              return 3

          def t0(self):
              if not hasattr(self, '_t0'):
                  self._t0 = time.time()
              return self._t0

          def t_end(self, now):
              if not hasattr(self, '_te') or self._te_phase != END:
                  self._te, self._te_phase = now, END
              return self._te

          # ---- Qt GUI ----
          def _build_gui(self):
              from PyQt5 import QtCore, QtGui, QtWidgets
              if QtWidgets.QApplication.instance() is None:
                  return
              node = self
              COL = ['#e53935', '#1e88e5', '#43a047', '#fdd835', '#8e24aa', '#fb8c00', '#00acc1', '#6d4c41',
                     '#ec407a', '#9ccc65', '#26a69a', '#7e57c2', '#ffa726', '#8d6e63', '#78909c', '#d4e157']
              TINT = ['#c9ccd3', '#c3d0d8', '#d3cbc3', '#c8d5c6', '#d0c6d6', '#d6d2bd']
              SC = {'T': '#f9a825', 'D': '#29b6f6', 'F': '#ff7043', 'G': '#8d6e63', 'R': '#ef5350', 'L': '#fff176',
                    'A': '#26a69a', 'Q': '#26c6da', 'V': '#d32f2f'}

              class Board(QtWidgets.QWidget):
                  def __init__(s):
                      super().__init__()
                      s.setMinimumSize(760, 420)
                      s.setFocusPolicy(QtCore.Qt.StrongFocus)

                  def paintEvent(s, _):
                      p = QtGui.QPainter(s)
                      p.setRenderHint(QtGui.QPainter.Antialiasing)
                      now = time.time()
                      p.fillRect(s.rect(), QtGui.QColor('#10141c'))
                      with node.lk:
                          v = node.view
                          mp = node.mp()
                          W, H = mp.W, mp.H
                          cs = min(s.width() / W, s.height() / H)
                          me = node.me
                          mepl = v['players'][me] if v and me < len(v['players']) else None
                          ingame = bool(v and v['phase'] in (PLAY, MEET))
                          mealive = bool(mepl and mepl[2] & 1)
                          lights = bool(v and v['flags'] & 1)
                          imp = node.role == IMP
                          mx, my = node.display_pos(me, now) if mepl else (0, 0)
                          R = 8.5 if imp else (2.6 if lights else 6.5)
                          x_i, y_i = (int(round(mx)), int(round(my)))
                          god = (not ingame) or (not mealive) or (mp.at(x_i, y_i) in 'AQ')
                          f = p.font()
                          f.setPixelSize(max(8, int(cs * .45)))
                          p.setFont(f)
                          for y in range(H):
                              for x in range(W):
                                  ch = mp.g[y][x]
                                  if ch == '#':
                                      col = '#2b3340'
                                  else:
                                      k = mp.col[y][x]
                                      col = TINT[k % len(TINT)] if k >= 0 else '#aeb2ba'
                                  p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(col))
                                  if ch in SC:
                                      inner, c = .6, SC[ch]
                                      if ch in 'TDF':
                                          kk = mp.tpos[(x, y)]
                                          if v and not v['active'] >> kk & 1:
                                              c = '#9aa0a6'
                                          elif v and v['done'] >> kk & 1:
                                              c = '#43a047'
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .2, y * cs + cs * .2, cs * inner, cs * inner), QtGui.QColor(c))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  elif ch in 'abcdef':
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .1, y * cs + cs * .3, cs * .8, cs * .4), QtGui.QColor('#3a2f2f'))
                                      p.setPen(QtGui.QColor('#bbbbbb'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  if ingame and not god and ch != '#' and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(0, 0, 0, 175))
                          p.setPen(QtGui.QColor(20, 20, 20, 170))
                          for nm, x0, y0, x1, y1 in mp.rooms:
                              p.drawText(QtCore.QRectF(x0 * cs, y0 * cs, (x1 - x0 + 1) * cs, cs * .9), QtCore.Qt.AlignCenter, nm)
                          if v:
                              for i, pl in enumerate(v['players']):
                                  if not pl[2] & 2:
                                      continue
                                  x, y = node.display_pos(i, now)
                                  if i != me and not god and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      continue
                                  c = QtGui.QColor(COL[i % 16])
                                  if pl[2] & 1:
                                      p.setBrush(c)
                                      partner = bool(imp and node.partners >> i & 1 and i != me)
                                      pen = QtGui.QColor('#ff1744') if partner else QtGui.QColor('white' if i == me else 'black')
                                      p.setPen(QtGui.QPen(pen, 3 if (i == me or partner) else 1))
                                      p.drawEllipse(QtCore.QRectF(x * cs + cs * .12, y * cs + cs * .12, cs * .76, cs * .76))
                                      if node.role == GRD and pl[5] >> 3 & 1:
                                          p.setBrush(QtCore.Qt.NoBrush)
                                          p.setPen(QtGui.QPen(QtGui.QColor('#4fc3f7'), 2))
                                          p.drawEllipse(QtCore.QRectF(x * cs, y * cs, cs, cs))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, str(i + 1))
                                  elif pl[2] & 4:
                                      p.setPen(QtGui.QPen(c, 4))
                                      p.drawLine(QtCore.QPointF(x * cs + 6, y * cs + 6), QtCore.QPointF(x * cs + cs - 6, y * cs + cs - 6))
                                      p.drawLine(QtCore.QPointF(x * cs + cs - 6, y * cs + 6), QtCore.QPointF(x * cs + 6, y * cs + cs * 1 - 6))
                          if v and v['flags'] & 2:
                              p.fillRect(QtCore.QRectF(0, 0, s.width(), 26), QtGui.QColor(200, 30, 30, 200))
                              p.setPen(QtGui.QColor('white'))
                              p.drawText(QtCore.QRectF(0, 0, s.width(), 26), QtCore.Qt.AlignCenter,
                                         "REACTOR MELTDOWN in %ds - two crew must press E on both red R panels within 4 s!" % v['sab_left'])
                      p.end()

                  KEYS = {QtCore.Qt.Key_Up: 1, QtCore.Qt.Key_W: 1, QtCore.Qt.Key_Down: 2, QtCore.Qt.Key_S: 2,
                          QtCore.Qt.Key_Left: 3, QtCore.Qt.Key_A: 3, QtCore.Qt.Key_Right: 4, QtCore.Qt.Key_D: 4}

                  def keyPressEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      Q = QtCore.Qt
                      if k:
                          held.append(k)
                          node.dirv = k
                      elif e.key() == Q.Key_E:
                          node.request_action(1)
                      elif e.key() == Q.Key_K:
                          node.request_action(2)
                      elif e.key() == Q.Key_R:
                          node.request_action(4)
                      elif e.key() == Q.Key_Z:
                          node.request_action(8)
                      elif e.key() == Q.Key_X:
                          node.request_action(0x40)
                      elif e.key() == Q.Key_V:
                          node.request_action(16)
                      elif e.key() == Q.Key_F:
                          node.request_action(32)
                      elif Q.Key_1 <= e.key() <= Q.Key_9:
                          node.cast_vote(e.key() - Q.Key_0)

                  def keyReleaseEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      if k in held:
                          held.remove(k)
                      node.dirv = held[-1] if held else 0

              held = []
              w = QtWidgets.QWidget()
              w.setWindowTitle("%s - %s" % (node.title, "HOST" if node.host else "Player %d" % (node.me + 1)))
              board = Board()
              status = QtWidgets.QLabel("")
              status.setWordWrap(True)
              plist = QtWidgets.QListWidget()
              tasks_lbl = QtWidgets.QLabel("")
              tasks_lbl.setStyleSheet("font-family: monospace; font-size: 11px")
              tasks_lbl.setAlignment(QtCore.Qt.AlignTop)
              chat = QtWidgets.QTextEdit()
              chat.setReadOnly(True)
              line = QtWidgets.QLineEdit()
              line.setPlaceholderText("chat (20 chars), Enter to send; Esc = back to map")
              btns = QtWidgets.QHBoxLayout()
              bt = {}
              for key, label, fn in [("use", "Use [E]", lambda: node.request_action(1)),
                                     ("kill", "Kill [K]", lambda: node.request_action(2)),
                                     ("report", "Report/Button [R]", lambda: node.request_action(4)),
                                     ("lights", "Lights out [Z]", lambda: node.request_action(8)),
                                     ("reactor", "Reactor [X]", lambda: node.request_action(0x40)),
                                     ("vent", "Vent [V]", lambda: node.request_action(16)),
                                     ("abil", "Ability [F]", lambda: node.request_action(32)),
                                     ("skip", "Skip vote", lambda: node.cast_vote(SKIP))]:
                  b = QtWidgets.QPushButton(label)
                  b.setFocusPolicy(QtCore.Qt.NoFocus)
                  b.clicked.connect(fn)
                  btns.addWidget(b)
                  bt[key] = b
              if node.host:
                  cb = QtWidgets.QComboBox()
                  cb.addItems(["Map: random"] + ["Map: " + m.name for m in MAPS])
                  cb.setFocusPolicy(QtCore.Qt.NoFocus)
                  cb.currentIndexChanged.connect(lambda i: setattr(node, 'map_pref', i))
                  btns.addWidget(cb)
                  sb = QtWidgets.QPushButton("START / NEW ROUND")
                  sb.setFocusPolicy(QtCore.Qt.NoFocus)
                  sb.clicked.connect(lambda: setattr(node, 'start_req', True))
                  btns.addWidget(sb)
              side = QtWidgets.QVBoxLayout()
              plbl = QtWidgets.QLabel("Players")
              for x in (plbl, plist, tasks_lbl, chat, line):
                  side.addWidget(x)
              plist.setMaximumHeight(210)
              top = QtWidgets.QHBoxLayout()
              top.addWidget(board, 3)
              top.addLayout(side, 1)
              lay = QtWidgets.QVBoxLayout(w)
              lay.addWidget(status)
              lay.addLayout(top)
              lay.addLayout(btns)
              line.returnPressed.connect(lambda: (node.send_chat(line.text()), line.clear()))
              plist.setFocusPolicy(QtCore.Qt.NoFocus)
              plist.itemClicked.connect(lambda it: node.cast_vote(plist.row(it) + 1))
              esc = QtWidgets.QShortcut(QtGui.QKeySequence("Esc"), w)
              esc.activated.connect(board.setFocus)
              names = ["LOBBY", "PLAYING", "MEETING", "GAME OVER"]

              def tick():
                  with node.lk:
                      v = node.view
                      if v:
                          mp = node.mp()
                          rl = node.role
                          r = "" if rl is None else "  |  You are %s: %s" % (ROLE_NAME[rl], ROLE_HELP[rl])
                          if rl == IMP and node.partners & ~(1 << node.me):
                              r += "  |  partner(s): " + ",".join("P%d" % (i + 1) for i in range(16) if node.partners >> i & 1 and i != node.me)
                          act_k = [k for k in range(len(mp.tasks)) if v['active'] >> k & 1]
                          dn = sum(1 for k in act_k if v['done'] >> k & 1)
                          t = "%s [%s]%s  |  tasks %d/%d" % (names[v['phase']], mp.name, r, dn, len(act_k))
                          if v['phase'] == PLAY and rl == IMP:
                              t += "  |  kill cd %ds, sabotage cd %ds" % (v['kill_left'], v['sab_cd'])
                          if v['flags'] & 1:
                              t += "  |  LIGHTS OUT: fix at yellow L (E)"
                          mv = "SKIP" if node.myvote == SKIP else ("P%d" % node.myvote if node.myvote else "none yet")
                          mepl = v['players'][node.me] if node.me < len(v['players']) else None
                          me_alive = mepl[2] & 1 if mepl else 0
                          if v['phase'] == MEET:
                              t += (("  |  VOTE NOW (%ds left): click a player in the list, press 1-9, or Skip vote. Your vote: %s" % (v['meet_left'], mv))
                                    if me_alive else "  |  meeting in progress (dead players cannot vote)")
                          if v['phase'] == END:
                              t += "  |  %s WIN (impostor(s): %s)" % ("CREW" if v['winner'] == 1 else "IMPOSTOR",
                                                                    ",".join("P%d" % (i + 1) for i in range(16) if v['reveal'] >> i & 1))
                          if mepl and not me_alive and v['phase'] in (PLAY, MEET):
                              t += "  |  you are DEAD (ghost view)"
                          if mepl and v['phase'] == PLAY:
                              if mepl[5] >> 2 & 1:
                                  t += "  |  carrying FUEL: use it at orange F"
                              if rl == ENG:
                                  t += "  |  vent hops left %d, remote fix %s" % (mepl[5] >> 4 & 3, "ready" if mepl[5] >> 6 & 1 else "used")
                              if mepl[5] & 3:
                                  t += "  |  download %d/3 (stay on the tile, press E)" % (mepl[5] & 3)
                          status.setText(t)
                          playing, meeting = v['phase'] == PLAY and me_alive, v['phase'] == MEET and me_alive
                          bt['use'].setEnabled(bool(playing))
                          bt['kill'].setEnabled(bool(playing and rl == IMP))
                          bt['report'].setEnabled(bool(playing))
                          bt['lights'].setEnabled(bool(playing and rl == IMP))
                          bt['reactor'].setEnabled(bool(playing and rl == IMP))
                          bt['vent'].setEnabled(bool(playing and rl in (IMP, ENG)))
                          bt['abil'].setEnabled(bool(playing and rl in (ENG, GRD)))
                          bt['skip'].setEnabled(bool(meeting))
                          plbl.setText("CLICK A PLAYER TO VOTE FOR THEM" if meeting else "Players")
                          if plist.count() != v['n']:
                              plist.clear()
                              for i in range(v['n']):
                                  plist.addItem("")
                          see_dead = v['phase'] != PLAY or rl == SCI or not me_alive or v['phase'] == END
                          for i, p in enumerate(v['players']):
                              it = plist.item(i)
                              it.setText("%d%s %s%s%s" % (i + 1, " (you)" if i == node.me else "", "" if p[2] & 2 else "[absent] ",
                                                           "" if (p[2] & 1 or not see_dead) else "[dead] ",
                                                           "[voted]" if p[2] & 8 else ("  <== your vote" if (meeting and node.myvote == i + 1) else "")))
                              it.setForeground(QtGui.QColor(COL[i % 16]))
                          lines = []
                          for k in act_k:
                              x, y, c = mp.tasks[k]
                              lines.append("%s %s @ %s" % ("[x]" if v['done'] >> k & 1 else "[ ]", {'T': 'Wiring', 'D': 'Download', 'F': 'Fuel'}[c], mp.room(x, y)))
                          tasks_lbl.setText("TASKS\n" + "\n".join(lines) if lines else "")
                      else:
                          status.setText("waiting for host signal...")
                      txt = "\n".join(node.chat_log)
                  if chat.toPlainText() != txt:
                      chat.setPlainText(txt)
                  board.update()

              tm = QtCore.QTimer(w)
              tm.timeout.connect(tick)
              tm.start(40)
              w.resize(1280, 720)
              w.show()
              board.setFocus()
              self.win = (w, tm)
    bot: '1'
    comment: 'Among Us Lite v2 node (up to 16 players, 2 maps, vents, sabotage, new roles). node_id 0 = host. map_pref: 0 random, 1/2 fixed.'
    guard_ms: guard_ms
    key: game_key
    map_pref: '0'
    min_players: '3'
    n_players: n_players
    node_id: '1'
    show_gui: '1'
    slot_ms: slot_ms
    tick_ms: tick_ms
    title: '''Among Us Lite'''
  states: {}
- name: game_client_2
  id: epy_block
  parameters:
    _source_code: |
      """Among Us Lite v2 node (host = node_id 0, clients = 1..n-1) for the QPSK GNU Radio link.
      Ports: rx_in (PDU from CRC Check 'ok'), tx_out (PDU to CRC Append).
      Wire format (all small): 5-byte header (magic|type, sender, dest, seq16) + payload (keystream-XOR) + 4-byte MAC.
      STATE (host->all, every tick) carries the whole world; INPUT (client->host) is sent in the client's own time slot.
      Events (use/kill/report/vent/sabotage/ability/chat) repeat until the host echoes their id, so no ACK packets are needed.
      v2: up to 16 players, 2 maps (random per round), 14+ tasks incl. multi-step ones, vents, sabotage (lights/reactor),
      fog of war, security/admin reveal, 2 impostors for 7+ players, roles: Crew, Impostor, Engineer, Scientist, Guardian.
      Keys: WASD/arrows move | E use | K kill | R report/button | Z lights-sabotage | X reactor-sabotage | V vent | F ability | 1-9 vote.
      """
      import hashlib, hmac, random, struct, threading, time
      from collections import deque
      from gnuradio import gr
      import pmt


      # ---------------- maps (built from rooms + corridors, identical on every node) ----------------
      class GMap:
          def __init__(s, name, W, H, rooms, cors, st):
              s.name, s.W, s.H = name, W, H
              s.g = [['#'] * W for _ in range(H)]
              s.rooms, s.col = [], [[-1] * W for _ in range(H)]
              for k, (nm, x0, y0, x1, y1) in enumerate(rooms):
                  s.rooms.append((nm, x0, y0, x1, y1))
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          s.g[y][x], s.col[y][x] = '.', k
              for x0, y0, x1, y1 in cors:
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          if s.g[y][x] == '#':
                              s.g[y][x] = '.'
              for ch, pts in st.items():
                  for x, y in pts:
                      assert s.g[y][x] == '.', (name, ch, x, y)
                      s.g[y][x] = ch
              s.rows = [''.join(r) for r in s.g]
              s.tasks = [(x, y, s.g[y][x]) for y in range(H) for x in range(W) if s.g[y][x] in 'TDF']
              assert len(s.tasks) <= 16
              s.tpos = {(x, y): k for k, (x, y, c) in enumerate(s.tasks)}
              s.button = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'V'][0]
              s.panels = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'R']
              s.vgroups, s.vent = {}, {}
              for ch in 'abcdef':
                  pts = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == ch]
                  if pts:
                      s.vgroups[ch] = pts
                      for i, p in enumerate(pts):
                          s.vent[p] = pts[(i + 1) % len(pts)]
              bx, by = s.button
              fl = [(abs(x - bx) + abs(y - by), x, y) for y in range(H) for x in range(W) if s.g[y][x] == '.']
              s.spawns = [(x, y) for _, x, y in sorted(fl)[:24]]

          def at(s, x, y):
              return s.g[y][x] if 0 <= x < s.W and 0 <= y < s.H else '#'

          def free(s, x, y):
              return s.at(x, y) != '#'

          def room(s, x, y):
              for nm, x0, y0, x1, y1 in s.rooms:
                  if x0 <= x <= x1 and y0 <= y <= y1:
                      return nm
              return 'hall'


      MAPS = [
          GMap('Skeld Lite', 44, 24,
               [('Upper Engine', 2, 1, 10, 6), ('Cafeteria', 15, 1, 28, 6), ('Weapons', 33, 1, 41, 6),
                ('Medbay', 2, 9, 10, 14), ('Admin', 15, 9, 21, 14), ('Storage', 23, 9, 28, 14), ('Navigation', 33, 9, 41, 14),
                ('Electrical', 2, 17, 10, 22), ('Reactor', 15, 17, 21, 22), ('Security', 23, 17, 28, 22), ('O2 / Shields', 33, 17, 41, 22)],
               [(11, 3, 14, 3), (29, 3, 32, 3), (11, 11, 14, 11), (29, 11, 32, 11), (22, 11, 22, 11), (11, 19, 14, 19),
                (29, 19, 32, 19), (22, 19, 22, 19), (5, 7, 5, 8), (18, 7, 18, 8), (25, 7, 25, 8), (37, 7, 37, 8),
                (5, 15, 5, 16), (18, 15, 18, 16), (25, 15, 25, 16), (37, 15, 37, 16)],
               {'V': [(21, 3)], 'T': [(17, 5), (26, 2), (4, 10), (20, 13), (35, 2), (35, 10), (4, 18), (35, 18), (26, 20), (16, 12)],
                'D': [(4, 2), (39, 5), (25, 10), (39, 20)], 'F': [(39, 13), (9, 21)], 'G': [(26, 13), (9, 18)],
                'R': [(16, 18), (3, 3)], 'L': [(8, 18)], 'A': [(17, 10)], 'Q': [(25, 19)],
                'a': [(9, 5), (3, 13), (3, 21)], 'b': [(27, 5), (40, 2), (40, 10)], 'c': [(16, 14), (27, 10), (20, 21)],
                'd': [(27, 22), (34, 21), (34, 5)]}),
          GMap('Outpost', 36, 20,
               [('Lab', 1, 1, 10, 5), ('Hangar', 25, 1, 34, 5), ('Armory', 1, 7, 8, 12), ('Hub', 13, 7, 22, 12),
                ('Comms', 27, 7, 34, 12), ('Quarters', 1, 14, 10, 18), ('Engine', 25, 14, 34, 18)],
               [(11, 3, 24, 3), (17, 4, 17, 6), (9, 9, 12, 9), (23, 9, 26, 9), (4, 6, 4, 6), (30, 6, 30, 6), (4, 13, 4, 13),
                (30, 13, 30, 13), (17, 13, 17, 16), (11, 16, 24, 16)],
               {'V': [(17, 9)], 'T': [(2, 8), (14, 8), (28, 8), (6, 15), (33, 3), (27, 16), (8, 3), (21, 11), (33, 11), (2, 17)],
                'D': [(7, 11), (26, 2), (9, 17), (31, 17)], 'F': [(33, 17), (5, 2)], 'G': [(2, 12), (28, 11)],
                'R': [(26, 15), (2, 2)], 'L': [(3, 15)], 'A': [(20, 8)], 'Q': [(32, 8)],
                'a': [(9, 5), (3, 9), (9, 15)], 'b': [(34, 5), (34, 12), (26, 17)], 'c': [(14, 11), (21, 8)]})
      ]

      DIRS = {1: (0, -1), 2: (0, 1), 3: (-1, 0), 4: (1, 0)}
      LOBBY, PLAY, MEET, END = 0, 1, 2, 3
      CREW, IMP, ENG, SCI, GRD = 0, 1, 2, 3, 4
      ROLE_NAME = {CREW: 'CREW', IMP: 'IMPOSTOR', ENG: 'ENGINEER', SCI: 'SCIENTIST', GRD: 'GUARDIAN'}
      ROLE_HELP = {CREW: 'do tasks (E)', IMP: 'kill K, vent V, sabotage Z/X', ENG: 'tasks + vent V (3 hops) + F = remote sabotage fix (1x)',
                   SCI: 'tasks + vitals: you see who is dead', GRD: 'tasks + F = shield nearest player (blocks 1 kill)'}
      T_STATE, T_INPUT, T_ROLE = 1, 2, 3
      BCAST, MAGIC, SKIP = 255, 0xA0, 0xFE
      MAXP = 16
      TASK_NAME = {'T': 'Wiring', 'D': 'Download (E x3, stay)', 'F': 'Fuel engine (take gas G first)'}


      def bfs_dir(mp, src, dst):
          if src == dst:
              return 0
          q, seen = deque([(src, 0)]), {src}
          while q:
              (x, y), first = q.popleft()
              for d, (dx, dy) in DIRS.items():
                  n = (x + dx, y + dy)
                  if n in seen or not mp.free(*n):
                      continue
                  if n == dst:
                      return first or d
                  seen.add(n)
                  q.append((n, first or d))
          return 0


      # ---------------- security / framing ----------------
      def _ks(key, hdr, n):
          out, c = b'', 0
          while len(out) < n:
              out += hashlib.sha256(key + hdr + bytes([c])).digest()
              c += 1
          return out[:n]


      def seal(key, typ, sender, dest, seq, payload):
          hdr = bytes([MAGIC | typ, sender, dest]) + struct.pack('!H', seq & 0xFFFF)
          ct = bytes(a ^ b for a, b in zip(payload, _ks(key, hdr, len(payload))))
          return hdr + ct + hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4]


      def unseal(key, raw):
          if len(raw) < 9 or (raw[0] & 0xF0) != MAGIC:
              return None
          hdr, ct, mac = raw[:5], raw[5:-4], raw[-4:]
          if not hmac.compare_digest(hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4], mac):
              return None
          pt = bytes(a ^ b for a, b in zip(ct, _ks(key, hdr, len(ct))))
          return hdr[0] & 0x0F, hdr[1], hdr[2], struct.unpack('!H', hdr[3:5])[0], pt


      def newer(seq, last):
          return last is None or 0 < ((seq - last) & 0xFFFF) < 0x8000


      # ---------------- authoritative game core (host only) ----------------
      class Core:
          def __init__(s, n, rng=None, kill_cd=8.0, meet_s=15.0, sab_cd=20.0, react_s=30.0, map_pref=0):
              s.n, s.rng, s.kill_cd, s.meet_s = n, rng or random.Random(), kill_cd, meet_s
              s.sab_cd, s.react_s, s.map_pref = sab_cd, react_s, map_pref
              s.mapid = 0
              s.lobby()

          @property
          def mp(s):
              return MAPS[s.mapid]

          def lobby(s):
              n = s.n
              s.phase, s.winner, s.done, s.active, s.eject = LOBBY, 0, 0, 0, 255
              s.imps, s.role = set(), [-1] * n
              s.inplay, s.alive, s.body = [0] * n, [1] * n, [0] * n
              s.dir, s.vote = [0] * n, [0] * n
              s.sp = list(s.mp.spawns)
              s.pos = [s.spawn(i) for i in range(n)]
              s.meet_end = s.sab_ready = 0
              s.kill_ready = [0.0] * n
              s.dl, s.fuel, s.shield = [[-1, 0] for _ in range(n)], [0] * n, [0] * n
              s.ventl, s.engfix, s.btn = [0] * n, [0] * n, [0] * n
              s.lights, s.react_end, s.rpanel = 0, 0.0, {}

          def spawn(s, i):
              return s.sp[i % len(s.sp)]

          def start(s, now, present):
              ids = [i for i in range(s.n) if present[i]]
              if len(ids) < 3:
                  return False
              s.lobby()
              mid = s.map_pref - 1 if 1 <= s.map_pref <= len(MAPS) else s.rng.randrange(len(MAPS))
              s.mapid = mid
              s.sp = list(s.mp.spawns)
              s.rng.shuffle(s.sp)
              s.pos = [s.spawn(i) for i in range(s.n)]
              s.phase = PLAY
              for i in ids:
                  s.inplay[i] = 1
              s.alive = [1 if s.inplay[i] else 0 for i in range(s.n)]
              order = ids[:]
              s.rng.shuffle(order)
              ni = 2 if len(ids) >= 7 else 1
              s.imps = set(order[:ni])
              crew = order[ni:]
              for i in ids:
                  s.role[i] = IMP if i in s.imps else CREW
              for r, need in ((ENG, 4), (SCI, 5), (GRD, 6)):
                  if len(ids) >= need and crew:
                      s.role[crew.pop()] = r
              for i in ids:
                  if s.role[i] == ENG:
                      s.ventl[i], s.engfix[i] = 3, 1
                  if i in s.imps:
                      s.kill_ready[i] = now + s.kill_cd
              ncrew = len(ids) - ni
              k = min(len(s.mp.tasks), max(5, 2 * ncrew + 2))
              for t in s.rng.sample(range(len(s.mp.tasks)), k):
                  s.active |= 1 << t
              s.sab_ready = now + s.sab_cd
              return True

          def end(s, w):
              s.phase, s.winner = END, w

          def check(s):
              crew = [i for i in range(s.n) if s.inplay[i] and s.alive[i] and i not in s.imps]
              imps = [i for i in s.imps if s.alive[i]]
              if not imps:
                  s.end(1)
              elif len(crew) <= len(imps):
                  s.end(2)

          def step(s, now):
              if s.phase == PLAY:
                  for i in range(s.n):
                      if s.inplay[i] and s.alive[i] and s.dir[i] in DIRS:
                          dx, dy = DIRS[s.dir[i]]
                          x, y = s.pos[i]
                          if s.mp.free(x + dx, y + dy):
                              s.pos[i] = (x + dx, y + dy)
                      t = s.dl[i][0]
                      if t >= 0 and s.pos[i] != s.mp.tasks[t][:2]:
                          s.dl[i] = [-1, 0]
                  if s.react_end and now >= s.react_end:
                      s.end(2)
              elif s.phase == MEET:
                  voters = [i for i in range(s.n) if s.inplay[i] and s.alive[i]]
                  if now >= s.meet_end or all(s.vote[i] for i in voters):
                      s.tally(now)

          def _use(s, p, x, y, now):
              mp, ch = s.mp, s.mp.at(x, y)
              if ch in 'TDF' and (x, y) in mp.tpos:
                  k = mp.tpos[(x, y)]
                  if not (s.active >> k & 1) or (s.done >> k & 1):
                      return
                  ok = False
                  if ch == 'T':
                      ok = True
                  elif ch == 'D':
                      s.dl[p] = [k, s.dl[p][1] + 1] if s.dl[p][0] == k else [k, 1]
                      if s.dl[p][1] >= 3:
                          ok, s.dl[p] = True, [-1, 0]
                  elif ch == 'F' and s.fuel[p]:
                      ok, s.fuel[p] = True, 0
                  if ok:
                      s.done |= 1 << k
                      if s.done & s.active == s.active:
                          s.end(1)
              elif ch == 'G':
                  s.fuel[p] = 1
              elif ch == 'L' and s.lights:
                  s.lights = 0
              elif ch == 'R' and s.react_end:
                  s.rpanel[(x, y)] = now
                  if all(now - s.rpanel.get(q, -99) <= 4.0 for q in mp.panels):
                      s.react_end, s.rpanel = 0.0, {}

          def act(s, p, a, now):
              if s.phase != PLAY or not s.inplay[p] or not s.alive[p]:
                  return
              x, y = s.pos[p]
              imp, role = p in s.imps, s.role[p]
              if a & 1 and not imp:
                  s._use(p, x, y, now)
                  if s.phase != PLAY:
                      return
              if a & 2 and imp and now >= s.kill_ready[p]:
                  best = None
                  for q in range(s.n):
                      if q != p and s.inplay[q] and s.alive[q] and q not in s.imps:
                          d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                          if d <= 2 and (best is None or d < best[0]):
                              best = (d, q)
                  if best:
                      q = best[1]
                      if s.shield[q]:
                          s.shield[q], s.kill_ready[p] = 0, now + 4.0
                      else:
                          s.alive[q], s.body[q], s.kill_ready[p] = 0, 1, now + s.kill_cd
                          s.check()
                          if s.phase != PLAY:
                              return
              if a & 4:
                  near = any(s.body[q] and abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y) <= 2 for q in range(s.n))
                  btn = (x, y) == s.mp.button and not s.btn[p] and not s.react_end
                  if near or btn:
                      if not near:
                          s.btn[p] = 1
                      s.phase, s.meet_end, s.vote, s.eject = MEET, now + s.meet_s, [0] * s.n, 255
                      s.body, s.dir = [0] * s.n, [0] * s.n
                      s.pos = [s.spawn(i) for i in range(s.n)]
                      s.dl = [[-1, 0] for _ in range(s.n)]
                      return
              if a & 8 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.lights, s.sab_ready = 1, now + s.sab_cd
              if a & 0x40 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.react_end, s.rpanel, s.sab_ready = now + s.react_s, {}, now + s.sab_cd + s.react_s
              if a & 16 and (imp or (role == ENG and s.ventl[p] > 0)) and (x, y) in s.mp.vent:
                  s.pos[p] = s.mp.vent[(x, y)]
                  if not imp:
                      s.ventl[p] -= 1
              if a & 32:
                  if role == ENG and s.engfix[p] > 0 and (s.lights or s.react_end):
                      s.lights, s.react_end, s.rpanel, s.engfix[p] = 0, 0.0, {}, 0
                  elif role == GRD:
                      best = None
                      for q in range(s.n):
                          if q != p and s.inplay[q] and s.alive[q]:
                              d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                              if d <= 3 and (best is None or d < best[0]):
                                  best = (d, q)
                      if best:
                          s.shield = [0] * s.n
                          s.shield[best[1]] = 1

          def set_vote(s, p, v):
              if s.phase == MEET and s.inplay[p] and s.alive[p]:
                  if v == SKIP or (1 <= v <= s.n and s.inplay[v - 1] and s.alive[v - 1]):
                      s.vote[p] = v

          def tally(s, now):
              cnt = {}
              for i in range(s.n):
                  if s.inplay[i] and s.alive[i] and s.vote[i]:
                      cnt[s.vote[i]] = cnt.get(s.vote[i], 0) + 1
              top = sorted(cnt.items(), key=lambda kv: -kv[1])
              s.eject = 254
              if top and (len(top) == 1 or top[0][1] > top[1][1]) and top[0][0] != SKIP:
                  q = top[0][0] - 1
                  s.alive[q], s.eject = 0, q
                  s.check()
                  if s.phase == END:
                      return
              s.phase, s.vote, s.dir = PLAY, [0] * s.n, [0] * s.n
              for i in s.imps:
                  s.kill_ready[i] = now + s.kill_cd
              s.sab_ready = now + s.sab_cd
              s.lights, s.react_end, s.rpanel, s.shield = 0, 0.0, {}, [0] * s.n
              s.pos = [s.spawn(i) for i in range(s.n)]

          def view(s, present, now, acks):
              pl = []
              for i in range(s.n):
                  fl = s.alive[i] | ((1 if (s.inplay[i] or present[i]) else 0) << 1) | (s.body[i] << 2) | ((1 if s.vote[i] else 0) << 3)
                  aux = (s.dl[i][1] & 3) | (s.fuel[i] << 2) | (s.shield[i] << 3) | ((s.ventl[i] & 3) << 4) | ((1 if s.engfix[i] else 0) << 6)
                  pl.append((s.pos[i][0], s.pos[i][1], fl, acks[0][i], acks[1][i], aux))
              kl = [s.kill_ready[i] - now for i in s.imps if s.alive[i]]
              mask = sum(1 << i for i in s.imps) if s.phase == END else 0
              return dict(phase=s.phase, winner=s.winner, done=s.done, active=s.active,
                          meet_left=int(max(0, s.meet_end - now)) if s.phase == MEET else 0,
                          n=s.n, mapid=s.mapid, reveal=mask, eject=s.eject,
                          flags=(1 if s.lights else 0) | (2 if s.react_end else 0),
                          sab_left=int(max(0, s.react_end - now)) if s.react_end else 0,
                          sab_cd=int(min(255, max(0, s.sab_ready - now))) if s.phase == PLAY else 0,
                          kill_left=int(min(255, max(0, min(kl)))) if (kl and s.phase == PLAY) else 0, players=pl)


      HDR = '!BBHHBBBHBBBBBBBB'


      def pack_state(v, chat):
          cid, cfrom, ctext = chat
          out = struct.pack(HDR, v['phase'], v['winner'], v['done'], v['active'], v['meet_left'], v['n'], v['mapid'],
                            v['reveal'], v['eject'], v['flags'], v['sab_left'], v['sab_cd'], v['kill_left'], cid, cfrom, len(ctext)) + ctext
          for x, y, fl, ca, ha, ax in v['players']:
              out += struct.pack('!BBBBBB', x, y, fl, ca, ha, ax)
          return out


      def unpack_state(pt):
          hs = struct.calcsize(HDR)
          ph, win, dn, ac, ml, n, mid, rev, ej, fg, sl, sc, kl, cid, cf, cl = struct.unpack(HDR, pt[:hs])
          text, o, pl = pt[hs:hs + cl], hs + cl, []
          for i in range(n):
              pl.append(struct.unpack('!BBBBBB', pt[o + 6 * i:o + 6 * i + 6]))
          return dict(phase=ph, winner=win, done=dn, active=ac, meet_left=ml, n=n, mapid=mid, reveal=rev, eject=ej, flags=fg,
                      sab_left=sl, sab_cd=sc, kill_left=kl, players=pl), (cid, cf, text)


      # ---------------- GNU Radio block ----------------
      class blk(gr.basic_block):
          def __init__(self, node_id=0, n_players=4, tick_ms=250, slot_ms=45, guard_ms=70,
                       key='change-this-game-key', show_gui=1, bot=0, min_players=3, title='Among Us Lite', map_pref=0):
              gr.basic_block.__init__(self, name="Among Us Lite Node", in_sig=None, out_sig=None)
              self.me, self.n = int(node_id), min(MAXP, max(3, int(n_players)))
              self.host = self.me == 0
              # TDMA frame must fit every client slot: stretch the tick automatically for big lobbies (same maths on every node)
              tick_ms = max(float(tick_ms), float(guard_ms) + (self.n - 1) * float(slot_ms) + 30.0)
              self.tick, self.slot, self.guard = tick_ms / 1000.0, slot_ms / 1000.0, guard_ms / 1000.0
              self.key = str(key).encode()
              self.show_gui, self.bot, self.title = bool(show_gui), bool(bot), str(title)
              self.map_pref = int(map_pref)
              self.lk = threading.RLock()
              self.running, self.seq, self.win = False, 0, None
              self.dirv, self.pending, self.myvote, self.start_req = 0, 0, 0, False
              self.chat_log, self.chat_out, self.cur_chat, self.last_chat_id = [], deque(), (0, b''), 0
              self.role, self.partners, self.view, self.t_state, self.prev, self.rng = None, 0, None, 0.0, {}, random.Random()
              self.cmd_id, self.bot_t, self.fail = 0, 0, 0
              if self.host:
                  self.core, self.last_rx = Core(self.n, map_pref=self.map_pref), [0.0] * self.n
                  self.cmd_seen, self.chat_seen, self.roleack = [0] * self.n, [0] * self.n, [0] * self.n
                  self.seq_in, self.hchat, self.chat_id, self.chat_cur, self.rr = [None] * self.n, deque(), 0, (0, 0, b''), 0
              else:
                  self.last_state_seq = None
              self._bridge = None
              if self.show_gui:
                  try:  # object created on the main (Qt) thread; its signal is queued to that thread
                      from PyQt5 import QtCore
                      if QtCore.QCoreApplication.instance() is not None:
                          class _Bridge(QtCore.QObject):
                              go = QtCore.pyqtSignal()
                          self._bridge = _Bridge()
                          self._bridge.go.connect(self._build_gui_safe)
                  except Exception as e:
                      print("game GUI bridge unavailable:", e)
              self.message_port_register_in(pmt.intern("rx_in"))
              self.message_port_register_out(pmt.intern("tx_out"))
              self.set_msg_handler(pmt.intern("rx_in"), self.handle_rx)

          # ---- lifecycle ----
          def start(self):
              self.running = True
              if self.host:
                  threading.Thread(target=self._host_loop, daemon=True).start()
              if self.show_gui:
                  if self._bridge is not None:
                      self._bridge.go.emit()
                  else:
                      self._build_gui_safe()
              return True

          def _build_gui_safe(self):
              try:
                  self._build_gui()
              except Exception as e:
                  print("game GUI disabled:", repr(e))

          def stop(self):
              self.running = False
              return True

          # ---- radio I/O ----
          def _send(self, typ, dest, payload):
              self.seq = (self.seq + 1) & 0xFFFF
              raw = seal(self.key, typ, self.me, dest, self.seq, payload)
              self.message_port_pub(pmt.intern("tx_out"), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def handle_rx(self, msg):
              try:
                  if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                      return
                  r = unseal(self.key, bytes(pmt.u8vector_elements(pmt.cdr(msg))))
                  if r is None:
                      self.fail += 1
                      return
                  typ, snd, dst, seq, pt = r
                  now = time.time()
                  if snd == self.me:
                      return
                  with self.lk:
                      if self.host and typ == T_INPUT and 0 < snd < self.n and dst == 0:
                          if newer(seq, self.seq_in[snd]):
                              self.seq_in[snd] = seq
                              self._on_input(snd, pt, now)
                      elif (not self.host) and snd == 0 and dst in (BCAST, self.me):
                          if typ == T_STATE and newer(seq, self.last_state_seq):
                              self.last_state_seq = seq
                              self._on_state(pt, now)
                          elif typ == T_ROLE and dst == self.me:
                              self.role = pt[0]
                              self.partners = struct.unpack('!H', pt[1:3])[0] if len(pt) >= 3 else 0
              except Exception as e:
                  print("game rx error:", repr(e))

          # ---- host ----
          def _on_input(self, p, pt, now):
              c = self.core
              d, cmd, act, vote, cid, cl = struct.unpack('!BBBBBB', pt[:6])
              text = pt[6:6 + cl]
              self.last_rx[p] = now
              c.dir[p] = d if d in DIRS else 0
              if act & 0x80:
                  self.roleack[p] = 1
              if (act & 0x7F) and cmd != self.cmd_seen[p]:
                  c.act(p, act & 0x7F, now)
              self.cmd_seen[p] = cmd
              c.set_vote(p, vote)
              if cid and cid != self.chat_seen[p]:
                  self.hchat.append((p, text[:20]))
                  self.chat_seen[p] = cid

          def _host_loop(self):
              nxt = time.time()
              while self.running:
                  now = time.time()
                  if now >= nxt:
                      nxt = max(nxt + self.tick, now + self.tick * 0.5)
                      try:
                          self._host_tick(now)
                      except Exception as e:
                          print("host tick error:", repr(e))
                  time.sleep(0.002)

          def _host_tick(self, now):
              with self.lk:
                  c = self.core
                  c.map_pref = self.map_pref
                  present = [1 if (i == 0 or now - self.last_rx[i] < 3.0) else 0 for i in range(self.n)]
                  if self.bot:
                      self._bot(self.view_host(present, now), now, present)
                  if self.start_req:
                      self.start_req = False
                      if c.phase in (LOBBY, END):
                          if c.phase == END:
                              c.lobby()
                          elif c.start(now, present):
                              self.roleack = [1 if i == 0 else 0 for i in range(self.n)]
                              self.role = c.role[0] if c.role[0] >= 0 else None
                              self.partners = sum(1 << i for i in c.imps) if c.role[0] == IMP else 0
                  c.dir[0] = self.dirv
                  if self.pending:
                      c.act(0, self.pending & 0x7F, now)
                      self.pending = 0
                  if c.phase == MEET:
                      c.set_vote(0, self.myvote)
                  for i in range(1, self.n):
                      if not present[i]:
                          c.dir[i] = 0
                  c.step(now)
                  if c.phase != MEET:
                      self.myvote = 0
                  if c.phase == LOBBY:
                      self.role, self.partners = None, 0
                  if self.hchat:
                      self.chat_id = self.chat_id % 255 + 1
                      f, t = self.hchat.popleft()
                      self.chat_cur = (self.chat_id, f, t)
                      self._log(f, t)
                  v = self.view_host(present, now)
                  self._set_view(v, now)
                  self._send(T_STATE, BCAST, pack_state(v, self.chat_cur))
                  if c.phase == PLAY:
                      for k in range(1, self.n):
                          p = 1 + (self.rr + k - 1) % (self.n - 1)
                          if c.inplay[p] and not self.roleack[p]:
                              self.rr = p
                              pm = sum(1 << i for i in c.imps) if p in c.imps else 0
                              self._send(T_ROLE, p, bytes([c.role[p]]) + struct.pack('!H', pm))
                              break

          def view_host(self, present, now):
              return self.core.view(present, now, (self.cmd_seen, self.chat_seen))

          # ---- client ----
          def _on_state(self, pt, now):
              v, chat = unpack_state(pt)
              self._set_view(v, now)
              cid, cf, text = chat
              if cid and cid != self.last_chat_id:
                  self.last_chat_id = cid
                  self._log(cf, text)
              if v['phase'] == LOBBY:
                  self.role, self.partners = None, 0
              if v['phase'] != MEET:
                  self.myvote = 0
              me = v['players'][self.me] if self.me < len(v['players']) else None
              if me:
                  if me[3] == self.cmd_id:
                      self.pending = 0
                  if self.cur_chat[0] and me[4] == self.cur_chat[0]:
                      self.cur_chat = (0, b'')
              if self.bot:
                  self._bot(v, now, None)
              delay = self.guard + (self.me - 1) * self.slot
              t = threading.Timer(delay, self._client_send)
              t.daemon = True
              t.start()

          def _client_send(self):
              if not self.running:
                  return
              with self.lk:
                  if not self.cur_chat[0] and self.chat_out:
                      nid = self.cur_chat_id = (getattr(self, 'cur_chat_id', 0) % 255) + 1
                      self.cur_chat = (nid, self.chat_out.popleft()[:20])
                  cid, ct = self.cur_chat
                  act = (self.pending & 0x7F) | (0x80 if self.role is not None else 0)
                  pl = struct.pack('!BBBBBB', self.dirv, self.cmd_id, act, self.myvote, cid, len(ct)) + ct
              self._send(T_INPUT, 0, pl)

          # ---- shared helpers ----
          def mp(self):
              return MAPS[self.view['mapid'] % len(MAPS)] if self.view else MAPS[0]

          def _set_view(self, v, now):
              old = self.view
              if old and old['mapid'] == v['mapid'] and len(old['players']) == len(v['players']):
                  self.prev = {i: self.display_pos(i, now) for i in range(len(old['players']))}
              else:
                  self.prev = {}
              self.view, self.t_state = v, now

          def display_pos(self, i, now):
              v = self.view
              if not v or i >= len(v['players']):
                  return (0, 0)
              x, y = v['players'][i][0], v['players'][i][1]
              px, py = self.prev.get(i, (x, y))
              if abs(px - x) + abs(py - y) > 3:  # vent hop / meeting respawn: snap
                  return (x, y)
              a = min(1.0, (now - self.t_state) / max(self.tick, 0.01))
              return (px + (x - px) * a, py + (y - py) * a)

          def _log(self, who, text):
              try:
                  s = text.decode('utf-8', 'replace')
              except Exception:
                  s = '?'
              self.chat_log.append("P%d: %s" % (who + 1, s))
              del self.chat_log[:-60]

          def request_action(self, bit):
              with self.lk:
                  if self.host:
                      self.pending = bit
                  elif not self.pending:
                      self.cmd_id = self.cmd_id % 255 + 1
                      self.pending = bit

          def send_chat(self, text):
              t = text.encode('utf-8')[:20]
              with self.lk:
                  if self.host:
                      self.hchat.append((0, t))
                  else:
                      self.chat_out.append(t)

          def cast_vote(self, v):
              with self.lk:
                  self.myvote = v

          def _bot(self, v, now, present):
              if now - self.bot_t < self.tick * 0.9:
                  return
              self.bot_t = now
              ph, me, mp = v['phase'], self.me, self.mp()
              pl = v['players']
              if ph == LOBBY:
                  if self.host and present is not None and sum(present) >= self.min_players_n() and now - self.t0() > 1.5:
                      self.start_req = True
                  return
              if ph == END:
                  if self.host and now - self.t_end(now) > 3:
                      self.start_req = True
                  return
              mypos, alive = (pl[me][0], pl[me][1]), pl[me][2] & 1
              if ph == MEET:
                  if alive and not self.myvote:
                      cands = [i + 1 for i in range(v['n']) if pl[i][2] & 1 and i != me and not (self.partners >> i & 1)]
                      self.cast_vote(self.rng.choice(cands + [SKIP]))
                  return
              self.dirv = 0
              if not alive:
                  return
              dist = lambda a, b: abs(a[0] - b[0]) + abs(a[1] - b[1])
              if self.role == IMP:
                  tg = [(dist(p, mypos), i) for i, p in enumerate(pl)
                        if i != me and p[2] & 1 and p[2] & 2 and not (self.partners >> i & 1)]
                  if v['sab_cd'] == 0 and not v['flags'] and self.rng.random() < 0.03:
                      self.request_action(8 if self.rng.random() < 0.7 else 0x40)
                  if tg:
                      d, i = min(tg)
                      if d <= 2 and self.rng.random() < 0.5:
                          self.request_action(2)
                      self.dirv = bfs_dir(mp, mypos, (pl[i][0], pl[i][1]))
              else:
                  if v['flags'] & 2:
                      tgt = min(mp.panels, key=lambda t: dist(t, mypos))
                      if mypos == tgt:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tgt)
                      return
                  if v['flags'] & 1:
                      lp = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'L'][0]
                      if mypos == lp:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, lp)
                      return
                  todo = [t for k, t in enumerate(mp.tasks) if v['active'] >> k & 1 and not v['done'] >> k & 1]
                  if todo:
                      fuel = pl[me][5] >> 2 & 1
                      if not fuel and any(t[2] == 'F' for t in todo):
                          gs = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'G']
                          todo = [min(gs, key=lambda g: dist(g, mypos)) + ('G',)]
                      else:
                          todo = [t for t in todo if t[2] != 'F' or fuel]
                      tg = min(todo, key=lambda t: dist(t, mypos))
                      if mypos == tg[:2]:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tg[:2])
                  bodies = [dist(p, mypos) for p in pl if p[2] & 4]
                  if bodies and min(bodies) <= 2:
                      self.request_action(4)

          def min_players_n(self):
              return 3

          def t0(self):
              if not hasattr(self, '_t0'):
                  self._t0 = time.time()
              return self._t0

          def t_end(self, now):
              if not hasattr(self, '_te') or self._te_phase != END:
                  self._te, self._te_phase = now, END
              return self._te

          # ---- Qt GUI ----
          def _build_gui(self):
              from PyQt5 import QtCore, QtGui, QtWidgets
              if QtWidgets.QApplication.instance() is None:
                  return
              node = self
              COL = ['#e53935', '#1e88e5', '#43a047', '#fdd835', '#8e24aa', '#fb8c00', '#00acc1', '#6d4c41',
                     '#ec407a', '#9ccc65', '#26a69a', '#7e57c2', '#ffa726', '#8d6e63', '#78909c', '#d4e157']
              TINT = ['#c9ccd3', '#c3d0d8', '#d3cbc3', '#c8d5c6', '#d0c6d6', '#d6d2bd']
              SC = {'T': '#f9a825', 'D': '#29b6f6', 'F': '#ff7043', 'G': '#8d6e63', 'R': '#ef5350', 'L': '#fff176',
                    'A': '#26a69a', 'Q': '#26c6da', 'V': '#d32f2f'}

              class Board(QtWidgets.QWidget):
                  def __init__(s):
                      super().__init__()
                      s.setMinimumSize(760, 420)
                      s.setFocusPolicy(QtCore.Qt.StrongFocus)

                  def paintEvent(s, _):
                      p = QtGui.QPainter(s)
                      p.setRenderHint(QtGui.QPainter.Antialiasing)
                      now = time.time()
                      p.fillRect(s.rect(), QtGui.QColor('#10141c'))
                      with node.lk:
                          v = node.view
                          mp = node.mp()
                          W, H = mp.W, mp.H
                          cs = min(s.width() / W, s.height() / H)
                          me = node.me
                          mepl = v['players'][me] if v and me < len(v['players']) else None
                          ingame = bool(v and v['phase'] in (PLAY, MEET))
                          mealive = bool(mepl and mepl[2] & 1)
                          lights = bool(v and v['flags'] & 1)
                          imp = node.role == IMP
                          mx, my = node.display_pos(me, now) if mepl else (0, 0)
                          R = 8.5 if imp else (2.6 if lights else 6.5)
                          x_i, y_i = (int(round(mx)), int(round(my)))
                          god = (not ingame) or (not mealive) or (mp.at(x_i, y_i) in 'AQ')
                          f = p.font()
                          f.setPixelSize(max(8, int(cs * .45)))
                          p.setFont(f)
                          for y in range(H):
                              for x in range(W):
                                  ch = mp.g[y][x]
                                  if ch == '#':
                                      col = '#2b3340'
                                  else:
                                      k = mp.col[y][x]
                                      col = TINT[k % len(TINT)] if k >= 0 else '#aeb2ba'
                                  p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(col))
                                  if ch in SC:
                                      inner, c = .6, SC[ch]
                                      if ch in 'TDF':
                                          kk = mp.tpos[(x, y)]
                                          if v and not v['active'] >> kk & 1:
                                              c = '#9aa0a6'
                                          elif v and v['done'] >> kk & 1:
                                              c = '#43a047'
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .2, y * cs + cs * .2, cs * inner, cs * inner), QtGui.QColor(c))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  elif ch in 'abcdef':
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .1, y * cs + cs * .3, cs * .8, cs * .4), QtGui.QColor('#3a2f2f'))
                                      p.setPen(QtGui.QColor('#bbbbbb'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  if ingame and not god and ch != '#' and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(0, 0, 0, 175))
                          p.setPen(QtGui.QColor(20, 20, 20, 170))
                          for nm, x0, y0, x1, y1 in mp.rooms:
                              p.drawText(QtCore.QRectF(x0 * cs, y0 * cs, (x1 - x0 + 1) * cs, cs * .9), QtCore.Qt.AlignCenter, nm)
                          if v:
                              for i, pl in enumerate(v['players']):
                                  if not pl[2] & 2:
                                      continue
                                  x, y = node.display_pos(i, now)
                                  if i != me and not god and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      continue
                                  c = QtGui.QColor(COL[i % 16])
                                  if pl[2] & 1:
                                      p.setBrush(c)
                                      partner = bool(imp and node.partners >> i & 1 and i != me)
                                      pen = QtGui.QColor('#ff1744') if partner else QtGui.QColor('white' if i == me else 'black')
                                      p.setPen(QtGui.QPen(pen, 3 if (i == me or partner) else 1))
                                      p.drawEllipse(QtCore.QRectF(x * cs + cs * .12, y * cs + cs * .12, cs * .76, cs * .76))
                                      if node.role == GRD and pl[5] >> 3 & 1:
                                          p.setBrush(QtCore.Qt.NoBrush)
                                          p.setPen(QtGui.QPen(QtGui.QColor('#4fc3f7'), 2))
                                          p.drawEllipse(QtCore.QRectF(x * cs, y * cs, cs, cs))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, str(i + 1))
                                  elif pl[2] & 4:
                                      p.setPen(QtGui.QPen(c, 4))
                                      p.drawLine(QtCore.QPointF(x * cs + 6, y * cs + 6), QtCore.QPointF(x * cs + cs - 6, y * cs + cs - 6))
                                      p.drawLine(QtCore.QPointF(x * cs + cs - 6, y * cs + 6), QtCore.QPointF(x * cs + 6, y * cs + cs * 1 - 6))
                          if v and v['flags'] & 2:
                              p.fillRect(QtCore.QRectF(0, 0, s.width(), 26), QtGui.QColor(200, 30, 30, 200))
                              p.setPen(QtGui.QColor('white'))
                              p.drawText(QtCore.QRectF(0, 0, s.width(), 26), QtCore.Qt.AlignCenter,
                                         "REACTOR MELTDOWN in %ds - two crew must press E on both red R panels within 4 s!" % v['sab_left'])
                      p.end()

                  KEYS = {QtCore.Qt.Key_Up: 1, QtCore.Qt.Key_W: 1, QtCore.Qt.Key_Down: 2, QtCore.Qt.Key_S: 2,
                          QtCore.Qt.Key_Left: 3, QtCore.Qt.Key_A: 3, QtCore.Qt.Key_Right: 4, QtCore.Qt.Key_D: 4}

                  def keyPressEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      Q = QtCore.Qt
                      if k:
                          held.append(k)
                          node.dirv = k
                      elif e.key() == Q.Key_E:
                          node.request_action(1)
                      elif e.key() == Q.Key_K:
                          node.request_action(2)
                      elif e.key() == Q.Key_R:
                          node.request_action(4)
                      elif e.key() == Q.Key_Z:
                          node.request_action(8)
                      elif e.key() == Q.Key_X:
                          node.request_action(0x40)
                      elif e.key() == Q.Key_V:
                          node.request_action(16)
                      elif e.key() == Q.Key_F:
                          node.request_action(32)
                      elif Q.Key_1 <= e.key() <= Q.Key_9:
                          node.cast_vote(e.key() - Q.Key_0)

                  def keyReleaseEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      if k in held:
                          held.remove(k)
                      node.dirv = held[-1] if held else 0

              held = []
              w = QtWidgets.QWidget()
              w.setWindowTitle("%s - %s" % (node.title, "HOST" if node.host else "Player %d" % (node.me + 1)))
              board = Board()
              status = QtWidgets.QLabel("")
              status.setWordWrap(True)
              plist = QtWidgets.QListWidget()
              tasks_lbl = QtWidgets.QLabel("")
              tasks_lbl.setStyleSheet("font-family: monospace; font-size: 11px")
              tasks_lbl.setAlignment(QtCore.Qt.AlignTop)
              chat = QtWidgets.QTextEdit()
              chat.setReadOnly(True)
              line = QtWidgets.QLineEdit()
              line.setPlaceholderText("chat (20 chars), Enter to send; Esc = back to map")
              btns = QtWidgets.QHBoxLayout()
              bt = {}
              for key, label, fn in [("use", "Use [E]", lambda: node.request_action(1)),
                                     ("kill", "Kill [K]", lambda: node.request_action(2)),
                                     ("report", "Report/Button [R]", lambda: node.request_action(4)),
                                     ("lights", "Lights out [Z]", lambda: node.request_action(8)),
                                     ("reactor", "Reactor [X]", lambda: node.request_action(0x40)),
                                     ("vent", "Vent [V]", lambda: node.request_action(16)),
                                     ("abil", "Ability [F]", lambda: node.request_action(32)),
                                     ("skip", "Skip vote", lambda: node.cast_vote(SKIP))]:
                  b = QtWidgets.QPushButton(label)
                  b.setFocusPolicy(QtCore.Qt.NoFocus)
                  b.clicked.connect(fn)
                  btns.addWidget(b)
                  bt[key] = b
              if node.host:
                  cb = QtWidgets.QComboBox()
                  cb.addItems(["Map: random"] + ["Map: " + m.name for m in MAPS])
                  cb.setFocusPolicy(QtCore.Qt.NoFocus)
                  cb.currentIndexChanged.connect(lambda i: setattr(node, 'map_pref', i))
                  btns.addWidget(cb)
                  sb = QtWidgets.QPushButton("START / NEW ROUND")
                  sb.setFocusPolicy(QtCore.Qt.NoFocus)
                  sb.clicked.connect(lambda: setattr(node, 'start_req', True))
                  btns.addWidget(sb)
              side = QtWidgets.QVBoxLayout()
              plbl = QtWidgets.QLabel("Players")
              for x in (plbl, plist, tasks_lbl, chat, line):
                  side.addWidget(x)
              plist.setMaximumHeight(210)
              top = QtWidgets.QHBoxLayout()
              top.addWidget(board, 3)
              top.addLayout(side, 1)
              lay = QtWidgets.QVBoxLayout(w)
              lay.addWidget(status)
              lay.addLayout(top)
              lay.addLayout(btns)
              line.returnPressed.connect(lambda: (node.send_chat(line.text()), line.clear()))
              plist.setFocusPolicy(QtCore.Qt.NoFocus)
              plist.itemClicked.connect(lambda it: node.cast_vote(plist.row(it) + 1))
              esc = QtWidgets.QShortcut(QtGui.QKeySequence("Esc"), w)
              esc.activated.connect(board.setFocus)
              names = ["LOBBY", "PLAYING", "MEETING", "GAME OVER"]

              def tick():
                  with node.lk:
                      v = node.view
                      if v:
                          mp = node.mp()
                          rl = node.role
                          r = "" if rl is None else "  |  You are %s: %s" % (ROLE_NAME[rl], ROLE_HELP[rl])
                          if rl == IMP and node.partners & ~(1 << node.me):
                              r += "  |  partner(s): " + ",".join("P%d" % (i + 1) for i in range(16) if node.partners >> i & 1 and i != node.me)
                          act_k = [k for k in range(len(mp.tasks)) if v['active'] >> k & 1]
                          dn = sum(1 for k in act_k if v['done'] >> k & 1)
                          t = "%s [%s]%s  |  tasks %d/%d" % (names[v['phase']], mp.name, r, dn, len(act_k))
                          if v['phase'] == PLAY and rl == IMP:
                              t += "  |  kill cd %ds, sabotage cd %ds" % (v['kill_left'], v['sab_cd'])
                          if v['flags'] & 1:
                              t += "  |  LIGHTS OUT: fix at yellow L (E)"
                          mv = "SKIP" if node.myvote == SKIP else ("P%d" % node.myvote if node.myvote else "none yet")
                          mepl = v['players'][node.me] if node.me < len(v['players']) else None
                          me_alive = mepl[2] & 1 if mepl else 0
                          if v['phase'] == MEET:
                              t += (("  |  VOTE NOW (%ds left): click a player in the list, press 1-9, or Skip vote. Your vote: %s" % (v['meet_left'], mv))
                                    if me_alive else "  |  meeting in progress (dead players cannot vote)")
                          if v['phase'] == END:
                              t += "  |  %s WIN (impostor(s): %s)" % ("CREW" if v['winner'] == 1 else "IMPOSTOR",
                                                                    ",".join("P%d" % (i + 1) for i in range(16) if v['reveal'] >> i & 1))
                          if mepl and not me_alive and v['phase'] in (PLAY, MEET):
                              t += "  |  you are DEAD (ghost view)"
                          if mepl and v['phase'] == PLAY:
                              if mepl[5] >> 2 & 1:
                                  t += "  |  carrying FUEL: use it at orange F"
                              if rl == ENG:
                                  t += "  |  vent hops left %d, remote fix %s" % (mepl[5] >> 4 & 3, "ready" if mepl[5] >> 6 & 1 else "used")
                              if mepl[5] & 3:
                                  t += "  |  download %d/3 (stay on the tile, press E)" % (mepl[5] & 3)
                          status.setText(t)
                          playing, meeting = v['phase'] == PLAY and me_alive, v['phase'] == MEET and me_alive
                          bt['use'].setEnabled(bool(playing))
                          bt['kill'].setEnabled(bool(playing and rl == IMP))
                          bt['report'].setEnabled(bool(playing))
                          bt['lights'].setEnabled(bool(playing and rl == IMP))
                          bt['reactor'].setEnabled(bool(playing and rl == IMP))
                          bt['vent'].setEnabled(bool(playing and rl in (IMP, ENG)))
                          bt['abil'].setEnabled(bool(playing and rl in (ENG, GRD)))
                          bt['skip'].setEnabled(bool(meeting))
                          plbl.setText("CLICK A PLAYER TO VOTE FOR THEM" if meeting else "Players")
                          if plist.count() != v['n']:
                              plist.clear()
                              for i in range(v['n']):
                                  plist.addItem("")
                          see_dead = v['phase'] != PLAY or rl == SCI or not me_alive or v['phase'] == END
                          for i, p in enumerate(v['players']):
                              it = plist.item(i)
                              it.setText("%d%s %s%s%s" % (i + 1, " (you)" if i == node.me else "", "" if p[2] & 2 else "[absent] ",
                                                           "" if (p[2] & 1 or not see_dead) else "[dead] ",
                                                           "[voted]" if p[2] & 8 else ("  <== your vote" if (meeting and node.myvote == i + 1) else "")))
                              it.setForeground(QtGui.QColor(COL[i % 16]))
                          lines = []
                          for k in act_k:
                              x, y, c = mp.tasks[k]
                              lines.append("%s %s @ %s" % ("[x]" if v['done'] >> k & 1 else "[ ]", {'T': 'Wiring', 'D': 'Download', 'F': 'Fuel'}[c], mp.room(x, y)))
                          tasks_lbl.setText("TASKS\n" + "\n".join(lines) if lines else "")
                      else:
                          status.setText("waiting for host signal...")
                      txt = "\n".join(node.chat_log)
                  if chat.toPlainText() != txt:
                      chat.setPlainText(txt)
                  board.update()

              tm = QtCore.QTimer(w)
              tm.timeout.connect(tick)
              tm.start(40)
              w.resize(1280, 720)
              w.show()
              board.setFocus()
              self.win = (w, tm)
    bot: '1'
    comment: 'Among Us Lite v2 node (up to 16 players, 2 maps, vents, sabotage, new roles). node_id 0 = host. map_pref: 0 random, 1/2 fixed.'
    guard_ms: guard_ms
    key: game_key
    map_pref: '0'
    min_players: '3'
    n_players: n_players
    node_id: '2'
    show_gui: '1'
    slot_ms: slot_ms
    tick_ms: tick_ms
    title: '''Among Us Lite'''
  states: {}
- name: game_client_3
  id: epy_block
  parameters:
    _source_code: |
      """Among Us Lite v2 node (host = node_id 0, clients = 1..n-1) for the QPSK GNU Radio link.
      Ports: rx_in (PDU from CRC Check 'ok'), tx_out (PDU to CRC Append).
      Wire format (all small): 5-byte header (magic|type, sender, dest, seq16) + payload (keystream-XOR) + 4-byte MAC.
      STATE (host->all, every tick) carries the whole world; INPUT (client->host) is sent in the client's own time slot.
      Events (use/kill/report/vent/sabotage/ability/chat) repeat until the host echoes their id, so no ACK packets are needed.
      v2: up to 16 players, 2 maps (random per round), 14+ tasks incl. multi-step ones, vents, sabotage (lights/reactor),
      fog of war, security/admin reveal, 2 impostors for 7+ players, roles: Crew, Impostor, Engineer, Scientist, Guardian.
      Keys: WASD/arrows move | E use | K kill | R report/button | Z lights-sabotage | X reactor-sabotage | V vent | F ability | 1-9 vote.
      """
      import hashlib, hmac, random, struct, threading, time
      from collections import deque
      from gnuradio import gr
      import pmt


      # ---------------- maps (built from rooms + corridors, identical on every node) ----------------
      class GMap:
          def __init__(s, name, W, H, rooms, cors, st):
              s.name, s.W, s.H = name, W, H
              s.g = [['#'] * W for _ in range(H)]
              s.rooms, s.col = [], [[-1] * W for _ in range(H)]
              for k, (nm, x0, y0, x1, y1) in enumerate(rooms):
                  s.rooms.append((nm, x0, y0, x1, y1))
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          s.g[y][x], s.col[y][x] = '.', k
              for x0, y0, x1, y1 in cors:
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          if s.g[y][x] == '#':
                              s.g[y][x] = '.'
              for ch, pts in st.items():
                  for x, y in pts:
                      assert s.g[y][x] == '.', (name, ch, x, y)
                      s.g[y][x] = ch
              s.rows = [''.join(r) for r in s.g]
              s.tasks = [(x, y, s.g[y][x]) for y in range(H) for x in range(W) if s.g[y][x] in 'TDF']
              assert len(s.tasks) <= 16
              s.tpos = {(x, y): k for k, (x, y, c) in enumerate(s.tasks)}
              s.button = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'V'][0]
              s.panels = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'R']
              s.vgroups, s.vent = {}, {}
              for ch in 'abcdef':
                  pts = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == ch]
                  if pts:
                      s.vgroups[ch] = pts
                      for i, p in enumerate(pts):
                          s.vent[p] = pts[(i + 1) % len(pts)]
              bx, by = s.button
              fl = [(abs(x - bx) + abs(y - by), x, y) for y in range(H) for x in range(W) if s.g[y][x] == '.']
              s.spawns = [(x, y) for _, x, y in sorted(fl)[:24]]

          def at(s, x, y):
              return s.g[y][x] if 0 <= x < s.W and 0 <= y < s.H else '#'

          def free(s, x, y):
              return s.at(x, y) != '#'

          def room(s, x, y):
              for nm, x0, y0, x1, y1 in s.rooms:
                  if x0 <= x <= x1 and y0 <= y <= y1:
                      return nm
              return 'hall'


      MAPS = [
          GMap('Skeld Lite', 44, 24,
               [('Upper Engine', 2, 1, 10, 6), ('Cafeteria', 15, 1, 28, 6), ('Weapons', 33, 1, 41, 6),
                ('Medbay', 2, 9, 10, 14), ('Admin', 15, 9, 21, 14), ('Storage', 23, 9, 28, 14), ('Navigation', 33, 9, 41, 14),
                ('Electrical', 2, 17, 10, 22), ('Reactor', 15, 17, 21, 22), ('Security', 23, 17, 28, 22), ('O2 / Shields', 33, 17, 41, 22)],
               [(11, 3, 14, 3), (29, 3, 32, 3), (11, 11, 14, 11), (29, 11, 32, 11), (22, 11, 22, 11), (11, 19, 14, 19),
                (29, 19, 32, 19), (22, 19, 22, 19), (5, 7, 5, 8), (18, 7, 18, 8), (25, 7, 25, 8), (37, 7, 37, 8),
                (5, 15, 5, 16), (18, 15, 18, 16), (25, 15, 25, 16), (37, 15, 37, 16)],
               {'V': [(21, 3)], 'T': [(17, 5), (26, 2), (4, 10), (20, 13), (35, 2), (35, 10), (4, 18), (35, 18), (26, 20), (16, 12)],
                'D': [(4, 2), (39, 5), (25, 10), (39, 20)], 'F': [(39, 13), (9, 21)], 'G': [(26, 13), (9, 18)],
                'R': [(16, 18), (3, 3)], 'L': [(8, 18)], 'A': [(17, 10)], 'Q': [(25, 19)],
                'a': [(9, 5), (3, 13), (3, 21)], 'b': [(27, 5), (40, 2), (40, 10)], 'c': [(16, 14), (27, 10), (20, 21)],
                'd': [(27, 22), (34, 21), (34, 5)]}),
          GMap('Outpost', 36, 20,
               [('Lab', 1, 1, 10, 5), ('Hangar', 25, 1, 34, 5), ('Armory', 1, 7, 8, 12), ('Hub', 13, 7, 22, 12),
                ('Comms', 27, 7, 34, 12), ('Quarters', 1, 14, 10, 18), ('Engine', 25, 14, 34, 18)],
               [(11, 3, 24, 3), (17, 4, 17, 6), (9, 9, 12, 9), (23, 9, 26, 9), (4, 6, 4, 6), (30, 6, 30, 6), (4, 13, 4, 13),
                (30, 13, 30, 13), (17, 13, 17, 16), (11, 16, 24, 16)],
               {'V': [(17, 9)], 'T': [(2, 8), (14, 8), (28, 8), (6, 15), (33, 3), (27, 16), (8, 3), (21, 11), (33, 11), (2, 17)],
                'D': [(7, 11), (26, 2), (9, 17), (31, 17)], 'F': [(33, 17), (5, 2)], 'G': [(2, 12), (28, 11)],
                'R': [(26, 15), (2, 2)], 'L': [(3, 15)], 'A': [(20, 8)], 'Q': [(32, 8)],
                'a': [(9, 5), (3, 9), (9, 15)], 'b': [(34, 5), (34, 12), (26, 17)], 'c': [(14, 11), (21, 8)]})
      ]

      DIRS = {1: (0, -1), 2: (0, 1), 3: (-1, 0), 4: (1, 0)}
      LOBBY, PLAY, MEET, END = 0, 1, 2, 3
      CREW, IMP, ENG, SCI, GRD = 0, 1, 2, 3, 4
      ROLE_NAME = {CREW: 'CREW', IMP: 'IMPOSTOR', ENG: 'ENGINEER', SCI: 'SCIENTIST', GRD: 'GUARDIAN'}
      ROLE_HELP = {CREW: 'do tasks (E)', IMP: 'kill K, vent V, sabotage Z/X', ENG: 'tasks + vent V (3 hops) + F = remote sabotage fix (1x)',
                   SCI: 'tasks + vitals: you see who is dead', GRD: 'tasks + F = shield nearest player (blocks 1 kill)'}
      T_STATE, T_INPUT, T_ROLE = 1, 2, 3
      BCAST, MAGIC, SKIP = 255, 0xA0, 0xFE
      MAXP = 16
      TASK_NAME = {'T': 'Wiring', 'D': 'Download (E x3, stay)', 'F': 'Fuel engine (take gas G first)'}


      def bfs_dir(mp, src, dst):
          if src == dst:
              return 0
          q, seen = deque([(src, 0)]), {src}
          while q:
              (x, y), first = q.popleft()
              for d, (dx, dy) in DIRS.items():
                  n = (x + dx, y + dy)
                  if n in seen or not mp.free(*n):
                      continue
                  if n == dst:
                      return first or d
                  seen.add(n)
                  q.append((n, first or d))
          return 0


      # ---------------- security / framing ----------------
      def _ks(key, hdr, n):
          out, c = b'', 0
          while len(out) < n:
              out += hashlib.sha256(key + hdr + bytes([c])).digest()
              c += 1
          return out[:n]


      def seal(key, typ, sender, dest, seq, payload):
          hdr = bytes([MAGIC | typ, sender, dest]) + struct.pack('!H', seq & 0xFFFF)
          ct = bytes(a ^ b for a, b in zip(payload, _ks(key, hdr, len(payload))))
          return hdr + ct + hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4]


      def unseal(key, raw):
          if len(raw) < 9 or (raw[0] & 0xF0) != MAGIC:
              return None
          hdr, ct, mac = raw[:5], raw[5:-4], raw[-4:]
          if not hmac.compare_digest(hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4], mac):
              return None
          pt = bytes(a ^ b for a, b in zip(ct, _ks(key, hdr, len(ct))))
          return hdr[0] & 0x0F, hdr[1], hdr[2], struct.unpack('!H', hdr[3:5])[0], pt


      def newer(seq, last):
          return last is None or 0 < ((seq - last) & 0xFFFF) < 0x8000


      # ---------------- authoritative game core (host only) ----------------
      class Core:
          def __init__(s, n, rng=None, kill_cd=8.0, meet_s=15.0, sab_cd=20.0, react_s=30.0, map_pref=0):
              s.n, s.rng, s.kill_cd, s.meet_s = n, rng or random.Random(), kill_cd, meet_s
              s.sab_cd, s.react_s, s.map_pref = sab_cd, react_s, map_pref
              s.mapid = 0
              s.lobby()

          @property
          def mp(s):
              return MAPS[s.mapid]

          def lobby(s):
              n = s.n
              s.phase, s.winner, s.done, s.active, s.eject = LOBBY, 0, 0, 0, 255
              s.imps, s.role = set(), [-1] * n
              s.inplay, s.alive, s.body = [0] * n, [1] * n, [0] * n
              s.dir, s.vote = [0] * n, [0] * n
              s.sp = list(s.mp.spawns)
              s.pos = [s.spawn(i) for i in range(n)]
              s.meet_end = s.sab_ready = 0
              s.kill_ready = [0.0] * n
              s.dl, s.fuel, s.shield = [[-1, 0] for _ in range(n)], [0] * n, [0] * n
              s.ventl, s.engfix, s.btn = [0] * n, [0] * n, [0] * n
              s.lights, s.react_end, s.rpanel = 0, 0.0, {}

          def spawn(s, i):
              return s.sp[i % len(s.sp)]

          def start(s, now, present):
              ids = [i for i in range(s.n) if present[i]]
              if len(ids) < 3:
                  return False
              s.lobby()
              mid = s.map_pref - 1 if 1 <= s.map_pref <= len(MAPS) else s.rng.randrange(len(MAPS))
              s.mapid = mid
              s.sp = list(s.mp.spawns)
              s.rng.shuffle(s.sp)
              s.pos = [s.spawn(i) for i in range(s.n)]
              s.phase = PLAY
              for i in ids:
                  s.inplay[i] = 1
              s.alive = [1 if s.inplay[i] else 0 for i in range(s.n)]
              order = ids[:]
              s.rng.shuffle(order)
              ni = 2 if len(ids) >= 7 else 1
              s.imps = set(order[:ni])
              crew = order[ni:]
              for i in ids:
                  s.role[i] = IMP if i in s.imps else CREW
              for r, need in ((ENG, 4), (SCI, 5), (GRD, 6)):
                  if len(ids) >= need and crew:
                      s.role[crew.pop()] = r
              for i in ids:
                  if s.role[i] == ENG:
                      s.ventl[i], s.engfix[i] = 3, 1
                  if i in s.imps:
                      s.kill_ready[i] = now + s.kill_cd
              ncrew = len(ids) - ni
              k = min(len(s.mp.tasks), max(5, 2 * ncrew + 2))
              for t in s.rng.sample(range(len(s.mp.tasks)), k):
                  s.active |= 1 << t
              s.sab_ready = now + s.sab_cd
              return True

          def end(s, w):
              s.phase, s.winner = END, w

          def check(s):
              crew = [i for i in range(s.n) if s.inplay[i] and s.alive[i] and i not in s.imps]
              imps = [i for i in s.imps if s.alive[i]]
              if not imps:
                  s.end(1)
              elif len(crew) <= len(imps):
                  s.end(2)

          def step(s, now):
              if s.phase == PLAY:
                  for i in range(s.n):
                      if s.inplay[i] and s.alive[i] and s.dir[i] in DIRS:
                          dx, dy = DIRS[s.dir[i]]
                          x, y = s.pos[i]
                          if s.mp.free(x + dx, y + dy):
                              s.pos[i] = (x + dx, y + dy)
                      t = s.dl[i][0]
                      if t >= 0 and s.pos[i] != s.mp.tasks[t][:2]:
                          s.dl[i] = [-1, 0]
                  if s.react_end and now >= s.react_end:
                      s.end(2)
              elif s.phase == MEET:
                  voters = [i for i in range(s.n) if s.inplay[i] and s.alive[i]]
                  if now >= s.meet_end or all(s.vote[i] for i in voters):
                      s.tally(now)

          def _use(s, p, x, y, now):
              mp, ch = s.mp, s.mp.at(x, y)
              if ch in 'TDF' and (x, y) in mp.tpos:
                  k = mp.tpos[(x, y)]
                  if not (s.active >> k & 1) or (s.done >> k & 1):
                      return
                  ok = False
                  if ch == 'T':
                      ok = True
                  elif ch == 'D':
                      s.dl[p] = [k, s.dl[p][1] + 1] if s.dl[p][0] == k else [k, 1]
                      if s.dl[p][1] >= 3:
                          ok, s.dl[p] = True, [-1, 0]
                  elif ch == 'F' and s.fuel[p]:
                      ok, s.fuel[p] = True, 0
                  if ok:
                      s.done |= 1 << k
                      if s.done & s.active == s.active:
                          s.end(1)
              elif ch == 'G':
                  s.fuel[p] = 1
              elif ch == 'L' and s.lights:
                  s.lights = 0
              elif ch == 'R' and s.react_end:
                  s.rpanel[(x, y)] = now
                  if all(now - s.rpanel.get(q, -99) <= 4.0 for q in mp.panels):
                      s.react_end, s.rpanel = 0.0, {}

          def act(s, p, a, now):
              if s.phase != PLAY or not s.inplay[p] or not s.alive[p]:
                  return
              x, y = s.pos[p]
              imp, role = p in s.imps, s.role[p]
              if a & 1 and not imp:
                  s._use(p, x, y, now)
                  if s.phase != PLAY:
                      return
              if a & 2 and imp and now >= s.kill_ready[p]:
                  best = None
                  for q in range(s.n):
                      if q != p and s.inplay[q] and s.alive[q] and q not in s.imps:
                          d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                          if d <= 2 and (best is None or d < best[0]):
                              best = (d, q)
                  if best:
                      q = best[1]
                      if s.shield[q]:
                          s.shield[q], s.kill_ready[p] = 0, now + 4.0
                      else:
                          s.alive[q], s.body[q], s.kill_ready[p] = 0, 1, now + s.kill_cd
                          s.check()
                          if s.phase != PLAY:
                              return
              if a & 4:
                  near = any(s.body[q] and abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y) <= 2 for q in range(s.n))
                  btn = (x, y) == s.mp.button and not s.btn[p] and not s.react_end
                  if near or btn:
                      if not near:
                          s.btn[p] = 1
                      s.phase, s.meet_end, s.vote, s.eject = MEET, now + s.meet_s, [0] * s.n, 255
                      s.body, s.dir = [0] * s.n, [0] * s.n
                      s.pos = [s.spawn(i) for i in range(s.n)]
                      s.dl = [[-1, 0] for _ in range(s.n)]
                      return
              if a & 8 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.lights, s.sab_ready = 1, now + s.sab_cd
              if a & 0x40 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.react_end, s.rpanel, s.sab_ready = now + s.react_s, {}, now + s.sab_cd + s.react_s
              if a & 16 and (imp or (role == ENG and s.ventl[p] > 0)) and (x, y) in s.mp.vent:
                  s.pos[p] = s.mp.vent[(x, y)]
                  if not imp:
                      s.ventl[p] -= 1
              if a & 32:
                  if role == ENG and s.engfix[p] > 0 and (s.lights or s.react_end):
                      s.lights, s.react_end, s.rpanel, s.engfix[p] = 0, 0.0, {}, 0
                  elif role == GRD:
                      best = None
                      for q in range(s.n):
                          if q != p and s.inplay[q] and s.alive[q]:
                              d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                              if d <= 3 and (best is None or d < best[0]):
                                  best = (d, q)
                      if best:
                          s.shield = [0] * s.n
                          s.shield[best[1]] = 1

          def set_vote(s, p, v):
              if s.phase == MEET and s.inplay[p] and s.alive[p]:
                  if v == SKIP or (1 <= v <= s.n and s.inplay[v - 1] and s.alive[v - 1]):
                      s.vote[p] = v

          def tally(s, now):
              cnt = {}
              for i in range(s.n):
                  if s.inplay[i] and s.alive[i] and s.vote[i]:
                      cnt[s.vote[i]] = cnt.get(s.vote[i], 0) + 1
              top = sorted(cnt.items(), key=lambda kv: -kv[1])
              s.eject = 254
              if top and (len(top) == 1 or top[0][1] > top[1][1]) and top[0][0] != SKIP:
                  q = top[0][0] - 1
                  s.alive[q], s.eject = 0, q
                  s.check()
                  if s.phase == END:
                      return
              s.phase, s.vote, s.dir = PLAY, [0] * s.n, [0] * s.n
              for i in s.imps:
                  s.kill_ready[i] = now + s.kill_cd
              s.sab_ready = now + s.sab_cd
              s.lights, s.react_end, s.rpanel, s.shield = 0, 0.0, {}, [0] * s.n
              s.pos = [s.spawn(i) for i in range(s.n)]

          def view(s, present, now, acks):
              pl = []
              for i in range(s.n):
                  fl = s.alive[i] | ((1 if (s.inplay[i] or present[i]) else 0) << 1) | (s.body[i] << 2) | ((1 if s.vote[i] else 0) << 3)
                  aux = (s.dl[i][1] & 3) | (s.fuel[i] << 2) | (s.shield[i] << 3) | ((s.ventl[i] & 3) << 4) | ((1 if s.engfix[i] else 0) << 6)
                  pl.append((s.pos[i][0], s.pos[i][1], fl, acks[0][i], acks[1][i], aux))
              kl = [s.kill_ready[i] - now for i in s.imps if s.alive[i]]
              mask = sum(1 << i for i in s.imps) if s.phase == END else 0
              return dict(phase=s.phase, winner=s.winner, done=s.done, active=s.active,
                          meet_left=int(max(0, s.meet_end - now)) if s.phase == MEET else 0,
                          n=s.n, mapid=s.mapid, reveal=mask, eject=s.eject,
                          flags=(1 if s.lights else 0) | (2 if s.react_end else 0),
                          sab_left=int(max(0, s.react_end - now)) if s.react_end else 0,
                          sab_cd=int(min(255, max(0, s.sab_ready - now))) if s.phase == PLAY else 0,
                          kill_left=int(min(255, max(0, min(kl)))) if (kl and s.phase == PLAY) else 0, players=pl)


      HDR = '!BBHHBBBHBBBBBBBB'


      def pack_state(v, chat):
          cid, cfrom, ctext = chat
          out = struct.pack(HDR, v['phase'], v['winner'], v['done'], v['active'], v['meet_left'], v['n'], v['mapid'],
                            v['reveal'], v['eject'], v['flags'], v['sab_left'], v['sab_cd'], v['kill_left'], cid, cfrom, len(ctext)) + ctext
          for x, y, fl, ca, ha, ax in v['players']:
              out += struct.pack('!BBBBBB', x, y, fl, ca, ha, ax)
          return out


      def unpack_state(pt):
          hs = struct.calcsize(HDR)
          ph, win, dn, ac, ml, n, mid, rev, ej, fg, sl, sc, kl, cid, cf, cl = struct.unpack(HDR, pt[:hs])
          text, o, pl = pt[hs:hs + cl], hs + cl, []
          for i in range(n):
              pl.append(struct.unpack('!BBBBBB', pt[o + 6 * i:o + 6 * i + 6]))
          return dict(phase=ph, winner=win, done=dn, active=ac, meet_left=ml, n=n, mapid=mid, reveal=rev, eject=ej, flags=fg,
                      sab_left=sl, sab_cd=sc, kill_left=kl, players=pl), (cid, cf, text)


      # ---------------- GNU Radio block ----------------
      class blk(gr.basic_block):
          def __init__(self, node_id=0, n_players=4, tick_ms=250, slot_ms=45, guard_ms=70,
                       key='change-this-game-key', show_gui=1, bot=0, min_players=3, title='Among Us Lite', map_pref=0):
              gr.basic_block.__init__(self, name="Among Us Lite Node", in_sig=None, out_sig=None)
              self.me, self.n = int(node_id), min(MAXP, max(3, int(n_players)))
              self.host = self.me == 0
              # TDMA frame must fit every client slot: stretch the tick automatically for big lobbies (same maths on every node)
              tick_ms = max(float(tick_ms), float(guard_ms) + (self.n - 1) * float(slot_ms) + 30.0)
              self.tick, self.slot, self.guard = tick_ms / 1000.0, slot_ms / 1000.0, guard_ms / 1000.0
              self.key = str(key).encode()
              self.show_gui, self.bot, self.title = bool(show_gui), bool(bot), str(title)
              self.map_pref = int(map_pref)
              self.lk = threading.RLock()
              self.running, self.seq, self.win = False, 0, None
              self.dirv, self.pending, self.myvote, self.start_req = 0, 0, 0, False
              self.chat_log, self.chat_out, self.cur_chat, self.last_chat_id = [], deque(), (0, b''), 0
              self.role, self.partners, self.view, self.t_state, self.prev, self.rng = None, 0, None, 0.0, {}, random.Random()
              self.cmd_id, self.bot_t, self.fail = 0, 0, 0
              if self.host:
                  self.core, self.last_rx = Core(self.n, map_pref=self.map_pref), [0.0] * self.n
                  self.cmd_seen, self.chat_seen, self.roleack = [0] * self.n, [0] * self.n, [0] * self.n
                  self.seq_in, self.hchat, self.chat_id, self.chat_cur, self.rr = [None] * self.n, deque(), 0, (0, 0, b''), 0
              else:
                  self.last_state_seq = None
              self._bridge = None
              if self.show_gui:
                  try:  # object created on the main (Qt) thread; its signal is queued to that thread
                      from PyQt5 import QtCore
                      if QtCore.QCoreApplication.instance() is not None:
                          class _Bridge(QtCore.QObject):
                              go = QtCore.pyqtSignal()
                          self._bridge = _Bridge()
                          self._bridge.go.connect(self._build_gui_safe)
                  except Exception as e:
                      print("game GUI bridge unavailable:", e)
              self.message_port_register_in(pmt.intern("rx_in"))
              self.message_port_register_out(pmt.intern("tx_out"))
              self.set_msg_handler(pmt.intern("rx_in"), self.handle_rx)

          # ---- lifecycle ----
          def start(self):
              self.running = True
              if self.host:
                  threading.Thread(target=self._host_loop, daemon=True).start()
              if self.show_gui:
                  if self._bridge is not None:
                      self._bridge.go.emit()
                  else:
                      self._build_gui_safe()
              return True

          def _build_gui_safe(self):
              try:
                  self._build_gui()
              except Exception as e:
                  print("game GUI disabled:", repr(e))

          def stop(self):
              self.running = False
              return True

          # ---- radio I/O ----
          def _send(self, typ, dest, payload):
              self.seq = (self.seq + 1) & 0xFFFF
              raw = seal(self.key, typ, self.me, dest, self.seq, payload)
              self.message_port_pub(pmt.intern("tx_out"), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def handle_rx(self, msg):
              try:
                  if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                      return
                  r = unseal(self.key, bytes(pmt.u8vector_elements(pmt.cdr(msg))))
                  if r is None:
                      self.fail += 1
                      return
                  typ, snd, dst, seq, pt = r
                  now = time.time()
                  if snd == self.me:
                      return
                  with self.lk:
                      if self.host and typ == T_INPUT and 0 < snd < self.n and dst == 0:
                          if newer(seq, self.seq_in[snd]):
                              self.seq_in[snd] = seq
                              self._on_input(snd, pt, now)
                      elif (not self.host) and snd == 0 and dst in (BCAST, self.me):
                          if typ == T_STATE and newer(seq, self.last_state_seq):
                              self.last_state_seq = seq
                              self._on_state(pt, now)
                          elif typ == T_ROLE and dst == self.me:
                              self.role = pt[0]
                              self.partners = struct.unpack('!H', pt[1:3])[0] if len(pt) >= 3 else 0
              except Exception as e:
                  print("game rx error:", repr(e))

          # ---- host ----
          def _on_input(self, p, pt, now):
              c = self.core
              d, cmd, act, vote, cid, cl = struct.unpack('!BBBBBB', pt[:6])
              text = pt[6:6 + cl]
              self.last_rx[p] = now
              c.dir[p] = d if d in DIRS else 0
              if act & 0x80:
                  self.roleack[p] = 1
              if (act & 0x7F) and cmd != self.cmd_seen[p]:
                  c.act(p, act & 0x7F, now)
              self.cmd_seen[p] = cmd
              c.set_vote(p, vote)
              if cid and cid != self.chat_seen[p]:
                  self.hchat.append((p, text[:20]))
                  self.chat_seen[p] = cid

          def _host_loop(self):
              nxt = time.time()
              while self.running:
                  now = time.time()
                  if now >= nxt:
                      nxt = max(nxt + self.tick, now + self.tick * 0.5)
                      try:
                          self._host_tick(now)
                      except Exception as e:
                          print("host tick error:", repr(e))
                  time.sleep(0.002)

          def _host_tick(self, now):
              with self.lk:
                  c = self.core
                  c.map_pref = self.map_pref
                  present = [1 if (i == 0 or now - self.last_rx[i] < 3.0) else 0 for i in range(self.n)]
                  if self.bot:
                      self._bot(self.view_host(present, now), now, present)
                  if self.start_req:
                      self.start_req = False
                      if c.phase in (LOBBY, END):
                          if c.phase == END:
                              c.lobby()
                          elif c.start(now, present):
                              self.roleack = [1 if i == 0 else 0 for i in range(self.n)]
                              self.role = c.role[0] if c.role[0] >= 0 else None
                              self.partners = sum(1 << i for i in c.imps) if c.role[0] == IMP else 0
                  c.dir[0] = self.dirv
                  if self.pending:
                      c.act(0, self.pending & 0x7F, now)
                      self.pending = 0
                  if c.phase == MEET:
                      c.set_vote(0, self.myvote)
                  for i in range(1, self.n):
                      if not present[i]:
                          c.dir[i] = 0
                  c.step(now)
                  if c.phase != MEET:
                      self.myvote = 0
                  if c.phase == LOBBY:
                      self.role, self.partners = None, 0
                  if self.hchat:
                      self.chat_id = self.chat_id % 255 + 1
                      f, t = self.hchat.popleft()
                      self.chat_cur = (self.chat_id, f, t)
                      self._log(f, t)
                  v = self.view_host(present, now)
                  self._set_view(v, now)
                  self._send(T_STATE, BCAST, pack_state(v, self.chat_cur))
                  if c.phase == PLAY:
                      for k in range(1, self.n):
                          p = 1 + (self.rr + k - 1) % (self.n - 1)
                          if c.inplay[p] and not self.roleack[p]:
                              self.rr = p
                              pm = sum(1 << i for i in c.imps) if p in c.imps else 0
                              self._send(T_ROLE, p, bytes([c.role[p]]) + struct.pack('!H', pm))
                              break

          def view_host(self, present, now):
              return self.core.view(present, now, (self.cmd_seen, self.chat_seen))

          # ---- client ----
          def _on_state(self, pt, now):
              v, chat = unpack_state(pt)
              self._set_view(v, now)
              cid, cf, text = chat
              if cid and cid != self.last_chat_id:
                  self.last_chat_id = cid
                  self._log(cf, text)
              if v['phase'] == LOBBY:
                  self.role, self.partners = None, 0
              if v['phase'] != MEET:
                  self.myvote = 0
              me = v['players'][self.me] if self.me < len(v['players']) else None
              if me:
                  if me[3] == self.cmd_id:
                      self.pending = 0
                  if self.cur_chat[0] and me[4] == self.cur_chat[0]:
                      self.cur_chat = (0, b'')
              if self.bot:
                  self._bot(v, now, None)
              delay = self.guard + (self.me - 1) * self.slot
              t = threading.Timer(delay, self._client_send)
              t.daemon = True
              t.start()

          def _client_send(self):
              if not self.running:
                  return
              with self.lk:
                  if not self.cur_chat[0] and self.chat_out:
                      nid = self.cur_chat_id = (getattr(self, 'cur_chat_id', 0) % 255) + 1
                      self.cur_chat = (nid, self.chat_out.popleft()[:20])
                  cid, ct = self.cur_chat
                  act = (self.pending & 0x7F) | (0x80 if self.role is not None else 0)
                  pl = struct.pack('!BBBBBB', self.dirv, self.cmd_id, act, self.myvote, cid, len(ct)) + ct
              self._send(T_INPUT, 0, pl)

          # ---- shared helpers ----
          def mp(self):
              return MAPS[self.view['mapid'] % len(MAPS)] if self.view else MAPS[0]

          def _set_view(self, v, now):
              old = self.view
              if old and old['mapid'] == v['mapid'] and len(old['players']) == len(v['players']):
                  self.prev = {i: self.display_pos(i, now) for i in range(len(old['players']))}
              else:
                  self.prev = {}
              self.view, self.t_state = v, now

          def display_pos(self, i, now):
              v = self.view
              if not v or i >= len(v['players']):
                  return (0, 0)
              x, y = v['players'][i][0], v['players'][i][1]
              px, py = self.prev.get(i, (x, y))
              if abs(px - x) + abs(py - y) > 3:  # vent hop / meeting respawn: snap
                  return (x, y)
              a = min(1.0, (now - self.t_state) / max(self.tick, 0.01))
              return (px + (x - px) * a, py + (y - py) * a)

          def _log(self, who, text):
              try:
                  s = text.decode('utf-8', 'replace')
              except Exception:
                  s = '?'
              self.chat_log.append("P%d: %s" % (who + 1, s))
              del self.chat_log[:-60]

          def request_action(self, bit):
              with self.lk:
                  if self.host:
                      self.pending = bit
                  elif not self.pending:
                      self.cmd_id = self.cmd_id % 255 + 1
                      self.pending = bit

          def send_chat(self, text):
              t = text.encode('utf-8')[:20]
              with self.lk:
                  if self.host:
                      self.hchat.append((0, t))
                  else:
                      self.chat_out.append(t)

          def cast_vote(self, v):
              with self.lk:
                  self.myvote = v

          def _bot(self, v, now, present):
              if now - self.bot_t < self.tick * 0.9:
                  return
              self.bot_t = now
              ph, me, mp = v['phase'], self.me, self.mp()
              pl = v['players']
              if ph == LOBBY:
                  if self.host and present is not None and sum(present) >= self.min_players_n() and now - self.t0() > 1.5:
                      self.start_req = True
                  return
              if ph == END:
                  if self.host and now - self.t_end(now) > 3:
                      self.start_req = True
                  return
              mypos, alive = (pl[me][0], pl[me][1]), pl[me][2] & 1
              if ph == MEET:
                  if alive and not self.myvote:
                      cands = [i + 1 for i in range(v['n']) if pl[i][2] & 1 and i != me and not (self.partners >> i & 1)]
                      self.cast_vote(self.rng.choice(cands + [SKIP]))
                  return
              self.dirv = 0
              if not alive:
                  return
              dist = lambda a, b: abs(a[0] - b[0]) + abs(a[1] - b[1])
              if self.role == IMP:
                  tg = [(dist(p, mypos), i) for i, p in enumerate(pl)
                        if i != me and p[2] & 1 and p[2] & 2 and not (self.partners >> i & 1)]
                  if v['sab_cd'] == 0 and not v['flags'] and self.rng.random() < 0.03:
                      self.request_action(8 if self.rng.random() < 0.7 else 0x40)
                  if tg:
                      d, i = min(tg)
                      if d <= 2 and self.rng.random() < 0.5:
                          self.request_action(2)
                      self.dirv = bfs_dir(mp, mypos, (pl[i][0], pl[i][1]))
              else:
                  if v['flags'] & 2:
                      tgt = min(mp.panels, key=lambda t: dist(t, mypos))
                      if mypos == tgt:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tgt)
                      return
                  if v['flags'] & 1:
                      lp = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'L'][0]
                      if mypos == lp:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, lp)
                      return
                  todo = [t for k, t in enumerate(mp.tasks) if v['active'] >> k & 1 and not v['done'] >> k & 1]
                  if todo:
                      fuel = pl[me][5] >> 2 & 1
                      if not fuel and any(t[2] == 'F' for t in todo):
                          gs = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'G']
                          todo = [min(gs, key=lambda g: dist(g, mypos)) + ('G',)]
                      else:
                          todo = [t for t in todo if t[2] != 'F' or fuel]
                      tg = min(todo, key=lambda t: dist(t, mypos))
                      if mypos == tg[:2]:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tg[:2])
                  bodies = [dist(p, mypos) for p in pl if p[2] & 4]
                  if bodies and min(bodies) <= 2:
                      self.request_action(4)

          def min_players_n(self):
              return 3

          def t0(self):
              if not hasattr(self, '_t0'):
                  self._t0 = time.time()
              return self._t0

          def t_end(self, now):
              if not hasattr(self, '_te') or self._te_phase != END:
                  self._te, self._te_phase = now, END
              return self._te

          # ---- Qt GUI ----
          def _build_gui(self):
              from PyQt5 import QtCore, QtGui, QtWidgets
              if QtWidgets.QApplication.instance() is None:
                  return
              node = self
              COL = ['#e53935', '#1e88e5', '#43a047', '#fdd835', '#8e24aa', '#fb8c00', '#00acc1', '#6d4c41',
                     '#ec407a', '#9ccc65', '#26a69a', '#7e57c2', '#ffa726', '#8d6e63', '#78909c', '#d4e157']
              TINT = ['#c9ccd3', '#c3d0d8', '#d3cbc3', '#c8d5c6', '#d0c6d6', '#d6d2bd']
              SC = {'T': '#f9a825', 'D': '#29b6f6', 'F': '#ff7043', 'G': '#8d6e63', 'R': '#ef5350', 'L': '#fff176',
                    'A': '#26a69a', 'Q': '#26c6da', 'V': '#d32f2f'}

              class Board(QtWidgets.QWidget):
                  def __init__(s):
                      super().__init__()
                      s.setMinimumSize(760, 420)
                      s.setFocusPolicy(QtCore.Qt.StrongFocus)

                  def paintEvent(s, _):
                      p = QtGui.QPainter(s)
                      p.setRenderHint(QtGui.QPainter.Antialiasing)
                      now = time.time()
                      p.fillRect(s.rect(), QtGui.QColor('#10141c'))
                      with node.lk:
                          v = node.view
                          mp = node.mp()
                          W, H = mp.W, mp.H
                          cs = min(s.width() / W, s.height() / H)
                          me = node.me
                          mepl = v['players'][me] if v and me < len(v['players']) else None
                          ingame = bool(v and v['phase'] in (PLAY, MEET))
                          mealive = bool(mepl and mepl[2] & 1)
                          lights = bool(v and v['flags'] & 1)
                          imp = node.role == IMP
                          mx, my = node.display_pos(me, now) if mepl else (0, 0)
                          R = 8.5 if imp else (2.6 if lights else 6.5)
                          x_i, y_i = (int(round(mx)), int(round(my)))
                          god = (not ingame) or (not mealive) or (mp.at(x_i, y_i) in 'AQ')
                          f = p.font()
                          f.setPixelSize(max(8, int(cs * .45)))
                          p.setFont(f)
                          for y in range(H):
                              for x in range(W):
                                  ch = mp.g[y][x]
                                  if ch == '#':
                                      col = '#2b3340'
                                  else:
                                      k = mp.col[y][x]
                                      col = TINT[k % len(TINT)] if k >= 0 else '#aeb2ba'
                                  p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(col))
                                  if ch in SC:
                                      inner, c = .6, SC[ch]
                                      if ch in 'TDF':
                                          kk = mp.tpos[(x, y)]
                                          if v and not v['active'] >> kk & 1:
                                              c = '#9aa0a6'
                                          elif v and v['done'] >> kk & 1:
                                              c = '#43a047'
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .2, y * cs + cs * .2, cs * inner, cs * inner), QtGui.QColor(c))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  elif ch in 'abcdef':
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .1, y * cs + cs * .3, cs * .8, cs * .4), QtGui.QColor('#3a2f2f'))
                                      p.setPen(QtGui.QColor('#bbbbbb'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  if ingame and not god and ch != '#' and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(0, 0, 0, 175))
                          p.setPen(QtGui.QColor(20, 20, 20, 170))
                          for nm, x0, y0, x1, y1 in mp.rooms:
                              p.drawText(QtCore.QRectF(x0 * cs, y0 * cs, (x1 - x0 + 1) * cs, cs * .9), QtCore.Qt.AlignCenter, nm)
                          if v:
                              for i, pl in enumerate(v['players']):
                                  if not pl[2] & 2:
                                      continue
                                  x, y = node.display_pos(i, now)
                                  if i != me and not god and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      continue
                                  c = QtGui.QColor(COL[i % 16])
                                  if pl[2] & 1:
                                      p.setBrush(c)
                                      partner = bool(imp and node.partners >> i & 1 and i != me)
                                      pen = QtGui.QColor('#ff1744') if partner else QtGui.QColor('white' if i == me else 'black')
                                      p.setPen(QtGui.QPen(pen, 3 if (i == me or partner) else 1))
                                      p.drawEllipse(QtCore.QRectF(x * cs + cs * .12, y * cs + cs * .12, cs * .76, cs * .76))
                                      if node.role == GRD and pl[5] >> 3 & 1:
                                          p.setBrush(QtCore.Qt.NoBrush)
                                          p.setPen(QtGui.QPen(QtGui.QColor('#4fc3f7'), 2))
                                          p.drawEllipse(QtCore.QRectF(x * cs, y * cs, cs, cs))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, str(i + 1))
                                  elif pl[2] & 4:
                                      p.setPen(QtGui.QPen(c, 4))
                                      p.drawLine(QtCore.QPointF(x * cs + 6, y * cs + 6), QtCore.QPointF(x * cs + cs - 6, y * cs + cs - 6))
                                      p.drawLine(QtCore.QPointF(x * cs + cs - 6, y * cs + 6), QtCore.QPointF(x * cs + 6, y * cs + cs * 1 - 6))
                          if v and v['flags'] & 2:
                              p.fillRect(QtCore.QRectF(0, 0, s.width(), 26), QtGui.QColor(200, 30, 30, 200))
                              p.setPen(QtGui.QColor('white'))
                              p.drawText(QtCore.QRectF(0, 0, s.width(), 26), QtCore.Qt.AlignCenter,
                                         "REACTOR MELTDOWN in %ds - two crew must press E on both red R panels within 4 s!" % v['sab_left'])
                      p.end()

                  KEYS = {QtCore.Qt.Key_Up: 1, QtCore.Qt.Key_W: 1, QtCore.Qt.Key_Down: 2, QtCore.Qt.Key_S: 2,
                          QtCore.Qt.Key_Left: 3, QtCore.Qt.Key_A: 3, QtCore.Qt.Key_Right: 4, QtCore.Qt.Key_D: 4}

                  def keyPressEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      Q = QtCore.Qt
                      if k:
                          held.append(k)
                          node.dirv = k
                      elif e.key() == Q.Key_E:
                          node.request_action(1)
                      elif e.key() == Q.Key_K:
                          node.request_action(2)
                      elif e.key() == Q.Key_R:
                          node.request_action(4)
                      elif e.key() == Q.Key_Z:
                          node.request_action(8)
                      elif e.key() == Q.Key_X:
                          node.request_action(0x40)
                      elif e.key() == Q.Key_V:
                          node.request_action(16)
                      elif e.key() == Q.Key_F:
                          node.request_action(32)
                      elif Q.Key_1 <= e.key() <= Q.Key_9:
                          node.cast_vote(e.key() - Q.Key_0)

                  def keyReleaseEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      if k in held:
                          held.remove(k)
                      node.dirv = held[-1] if held else 0

              held = []
              w = QtWidgets.QWidget()
              w.setWindowTitle("%s - %s" % (node.title, "HOST" if node.host else "Player %d" % (node.me + 1)))
              board = Board()
              status = QtWidgets.QLabel("")
              status.setWordWrap(True)
              plist = QtWidgets.QListWidget()
              tasks_lbl = QtWidgets.QLabel("")
              tasks_lbl.setStyleSheet("font-family: monospace; font-size: 11px")
              tasks_lbl.setAlignment(QtCore.Qt.AlignTop)
              chat = QtWidgets.QTextEdit()
              chat.setReadOnly(True)
              line = QtWidgets.QLineEdit()
              line.setPlaceholderText("chat (20 chars), Enter to send; Esc = back to map")
              btns = QtWidgets.QHBoxLayout()
              bt = {}
              for key, label, fn in [("use", "Use [E]", lambda: node.request_action(1)),
                                     ("kill", "Kill [K]", lambda: node.request_action(2)),
                                     ("report", "Report/Button [R]", lambda: node.request_action(4)),
                                     ("lights", "Lights out [Z]", lambda: node.request_action(8)),
                                     ("reactor", "Reactor [X]", lambda: node.request_action(0x40)),
                                     ("vent", "Vent [V]", lambda: node.request_action(16)),
                                     ("abil", "Ability [F]", lambda: node.request_action(32)),
                                     ("skip", "Skip vote", lambda: node.cast_vote(SKIP))]:
                  b = QtWidgets.QPushButton(label)
                  b.setFocusPolicy(QtCore.Qt.NoFocus)
                  b.clicked.connect(fn)
                  btns.addWidget(b)
                  bt[key] = b
              if node.host:
                  cb = QtWidgets.QComboBox()
                  cb.addItems(["Map: random"] + ["Map: " + m.name for m in MAPS])
                  cb.setFocusPolicy(QtCore.Qt.NoFocus)
                  cb.currentIndexChanged.connect(lambda i: setattr(node, 'map_pref', i))
                  btns.addWidget(cb)
                  sb = QtWidgets.QPushButton("START / NEW ROUND")
                  sb.setFocusPolicy(QtCore.Qt.NoFocus)
                  sb.clicked.connect(lambda: setattr(node, 'start_req', True))
                  btns.addWidget(sb)
              side = QtWidgets.QVBoxLayout()
              plbl = QtWidgets.QLabel("Players")
              for x in (plbl, plist, tasks_lbl, chat, line):
                  side.addWidget(x)
              plist.setMaximumHeight(210)
              top = QtWidgets.QHBoxLayout()
              top.addWidget(board, 3)
              top.addLayout(side, 1)
              lay = QtWidgets.QVBoxLayout(w)
              lay.addWidget(status)
              lay.addLayout(top)
              lay.addLayout(btns)
              line.returnPressed.connect(lambda: (node.send_chat(line.text()), line.clear()))
              plist.setFocusPolicy(QtCore.Qt.NoFocus)
              plist.itemClicked.connect(lambda it: node.cast_vote(plist.row(it) + 1))
              esc = QtWidgets.QShortcut(QtGui.QKeySequence("Esc"), w)
              esc.activated.connect(board.setFocus)
              names = ["LOBBY", "PLAYING", "MEETING", "GAME OVER"]

              def tick():
                  with node.lk:
                      v = node.view
                      if v:
                          mp = node.mp()
                          rl = node.role
                          r = "" if rl is None else "  |  You are %s: %s" % (ROLE_NAME[rl], ROLE_HELP[rl])
                          if rl == IMP and node.partners & ~(1 << node.me):
                              r += "  |  partner(s): " + ",".join("P%d" % (i + 1) for i in range(16) if node.partners >> i & 1 and i != node.me)
                          act_k = [k for k in range(len(mp.tasks)) if v['active'] >> k & 1]
                          dn = sum(1 for k in act_k if v['done'] >> k & 1)
                          t = "%s [%s]%s  |  tasks %d/%d" % (names[v['phase']], mp.name, r, dn, len(act_k))
                          if v['phase'] == PLAY and rl == IMP:
                              t += "  |  kill cd %ds, sabotage cd %ds" % (v['kill_left'], v['sab_cd'])
                          if v['flags'] & 1:
                              t += "  |  LIGHTS OUT: fix at yellow L (E)"
                          mv = "SKIP" if node.myvote == SKIP else ("P%d" % node.myvote if node.myvote else "none yet")
                          mepl = v['players'][node.me] if node.me < len(v['players']) else None
                          me_alive = mepl[2] & 1 if mepl else 0
                          if v['phase'] == MEET:
                              t += (("  |  VOTE NOW (%ds left): click a player in the list, press 1-9, or Skip vote. Your vote: %s" % (v['meet_left'], mv))
                                    if me_alive else "  |  meeting in progress (dead players cannot vote)")
                          if v['phase'] == END:
                              t += "  |  %s WIN (impostor(s): %s)" % ("CREW" if v['winner'] == 1 else "IMPOSTOR",
                                                                    ",".join("P%d" % (i + 1) for i in range(16) if v['reveal'] >> i & 1))
                          if mepl and not me_alive and v['phase'] in (PLAY, MEET):
                              t += "  |  you are DEAD (ghost view)"
                          if mepl and v['phase'] == PLAY:
                              if mepl[5] >> 2 & 1:
                                  t += "  |  carrying FUEL: use it at orange F"
                              if rl == ENG:
                                  t += "  |  vent hops left %d, remote fix %s" % (mepl[5] >> 4 & 3, "ready" if mepl[5] >> 6 & 1 else "used")
                              if mepl[5] & 3:
                                  t += "  |  download %d/3 (stay on the tile, press E)" % (mepl[5] & 3)
                          status.setText(t)
                          playing, meeting = v['phase'] == PLAY and me_alive, v['phase'] == MEET and me_alive
                          bt['use'].setEnabled(bool(playing))
                          bt['kill'].setEnabled(bool(playing and rl == IMP))
                          bt['report'].setEnabled(bool(playing))
                          bt['lights'].setEnabled(bool(playing and rl == IMP))
                          bt['reactor'].setEnabled(bool(playing and rl == IMP))
                          bt['vent'].setEnabled(bool(playing and rl in (IMP, ENG)))
                          bt['abil'].setEnabled(bool(playing and rl in (ENG, GRD)))
                          bt['skip'].setEnabled(bool(meeting))
                          plbl.setText("CLICK A PLAYER TO VOTE FOR THEM" if meeting else "Players")
                          if plist.count() != v['n']:
                              plist.clear()
                              for i in range(v['n']):
                                  plist.addItem("")
                          see_dead = v['phase'] != PLAY or rl == SCI or not me_alive or v['phase'] == END
                          for i, p in enumerate(v['players']):
                              it = plist.item(i)
                              it.setText("%d%s %s%s%s" % (i + 1, " (you)" if i == node.me else "", "" if p[2] & 2 else "[absent] ",
                                                           "" if (p[2] & 1 or not see_dead) else "[dead] ",
                                                           "[voted]" if p[2] & 8 else ("  <== your vote" if (meeting and node.myvote == i + 1) else "")))
                              it.setForeground(QtGui.QColor(COL[i % 16]))
                          lines = []
                          for k in act_k:
                              x, y, c = mp.tasks[k]
                              lines.append("%s %s @ %s" % ("[x]" if v['done'] >> k & 1 else "[ ]", {'T': 'Wiring', 'D': 'Download', 'F': 'Fuel'}[c], mp.room(x, y)))
                          tasks_lbl.setText("TASKS\n" + "\n".join(lines) if lines else "")
                      else:
                          status.setText("waiting for host signal...")
                      txt = "\n".join(node.chat_log)
                  if chat.toPlainText() != txt:
                      chat.setPlainText(txt)
                  board.update()

              tm = QtCore.QTimer(w)
              tm.timeout.connect(tick)
              tm.start(40)
              w.resize(1280, 720)
              w.show()
              board.setFocus()
              self.win = (w, tm)
    bot: '1'
    comment: 'Among Us Lite v2 node (up to 16 players, 2 maps, vents, sabotage, new roles). node_id 0 = host. map_pref: 0 random, 1/2 fixed.'
    guard_ms: guard_ms
    key: game_key
    map_pref: '0'
    min_players: '3'
    n_players: n_players
    node_id: '3'
    show_gui: '1'
    slot_ms: slot_ms
    tick_ms: tick_ms
    title: '''Among Us Lite'''
  states: {}
- name: game_host
  id: epy_block
  parameters:
    _source_code: |
      """Among Us Lite v2 node (host = node_id 0, clients = 1..n-1) for the QPSK GNU Radio link.
      Ports: rx_in (PDU from CRC Check 'ok'), tx_out (PDU to CRC Append).
      Wire format (all small): 5-byte header (magic|type, sender, dest, seq16) + payload (keystream-XOR) + 4-byte MAC.
      STATE (host->all, every tick) carries the whole world; INPUT (client->host) is sent in the client's own time slot.
      Events (use/kill/report/vent/sabotage/ability/chat) repeat until the host echoes their id, so no ACK packets are needed.
      v2: up to 16 players, 2 maps (random per round), 14+ tasks incl. multi-step ones, vents, sabotage (lights/reactor),
      fog of war, security/admin reveal, 2 impostors for 7+ players, roles: Crew, Impostor, Engineer, Scientist, Guardian.
      Keys: WASD/arrows move | E use | K kill | R report/button | Z lights-sabotage | X reactor-sabotage | V vent | F ability | 1-9 vote.
      """
      import hashlib, hmac, random, struct, threading, time
      from collections import deque
      from gnuradio import gr
      import pmt


      # ---------------- maps (built from rooms + corridors, identical on every node) ----------------
      class GMap:
          def __init__(s, name, W, H, rooms, cors, st):
              s.name, s.W, s.H = name, W, H
              s.g = [['#'] * W for _ in range(H)]
              s.rooms, s.col = [], [[-1] * W for _ in range(H)]
              for k, (nm, x0, y0, x1, y1) in enumerate(rooms):
                  s.rooms.append((nm, x0, y0, x1, y1))
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          s.g[y][x], s.col[y][x] = '.', k
              for x0, y0, x1, y1 in cors:
                  for y in range(y0, y1 + 1):
                      for x in range(x0, x1 + 1):
                          if s.g[y][x] == '#':
                              s.g[y][x] = '.'
              for ch, pts in st.items():
                  for x, y in pts:
                      assert s.g[y][x] == '.', (name, ch, x, y)
                      s.g[y][x] = ch
              s.rows = [''.join(r) for r in s.g]
              s.tasks = [(x, y, s.g[y][x]) for y in range(H) for x in range(W) if s.g[y][x] in 'TDF']
              assert len(s.tasks) <= 16
              s.tpos = {(x, y): k for k, (x, y, c) in enumerate(s.tasks)}
              s.button = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'V'][0]
              s.panels = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == 'R']
              s.vgroups, s.vent = {}, {}
              for ch in 'abcdef':
                  pts = [(x, y) for y in range(H) for x in range(W) if s.g[y][x] == ch]
                  if pts:
                      s.vgroups[ch] = pts
                      for i, p in enumerate(pts):
                          s.vent[p] = pts[(i + 1) % len(pts)]
              bx, by = s.button
              fl = [(abs(x - bx) + abs(y - by), x, y) for y in range(H) for x in range(W) if s.g[y][x] == '.']
              s.spawns = [(x, y) for _, x, y in sorted(fl)[:24]]

          def at(s, x, y):
              return s.g[y][x] if 0 <= x < s.W and 0 <= y < s.H else '#'

          def free(s, x, y):
              return s.at(x, y) != '#'

          def room(s, x, y):
              for nm, x0, y0, x1, y1 in s.rooms:
                  if x0 <= x <= x1 and y0 <= y <= y1:
                      return nm
              return 'hall'


      MAPS = [
          GMap('Skeld Lite', 44, 24,
               [('Upper Engine', 2, 1, 10, 6), ('Cafeteria', 15, 1, 28, 6), ('Weapons', 33, 1, 41, 6),
                ('Medbay', 2, 9, 10, 14), ('Admin', 15, 9, 21, 14), ('Storage', 23, 9, 28, 14), ('Navigation', 33, 9, 41, 14),
                ('Electrical', 2, 17, 10, 22), ('Reactor', 15, 17, 21, 22), ('Security', 23, 17, 28, 22), ('O2 / Shields', 33, 17, 41, 22)],
               [(11, 3, 14, 3), (29, 3, 32, 3), (11, 11, 14, 11), (29, 11, 32, 11), (22, 11, 22, 11), (11, 19, 14, 19),
                (29, 19, 32, 19), (22, 19, 22, 19), (5, 7, 5, 8), (18, 7, 18, 8), (25, 7, 25, 8), (37, 7, 37, 8),
                (5, 15, 5, 16), (18, 15, 18, 16), (25, 15, 25, 16), (37, 15, 37, 16)],
               {'V': [(21, 3)], 'T': [(17, 5), (26, 2), (4, 10), (20, 13), (35, 2), (35, 10), (4, 18), (35, 18), (26, 20), (16, 12)],
                'D': [(4, 2), (39, 5), (25, 10), (39, 20)], 'F': [(39, 13), (9, 21)], 'G': [(26, 13), (9, 18)],
                'R': [(16, 18), (3, 3)], 'L': [(8, 18)], 'A': [(17, 10)], 'Q': [(25, 19)],
                'a': [(9, 5), (3, 13), (3, 21)], 'b': [(27, 5), (40, 2), (40, 10)], 'c': [(16, 14), (27, 10), (20, 21)],
                'd': [(27, 22), (34, 21), (34, 5)]}),
          GMap('Outpost', 36, 20,
               [('Lab', 1, 1, 10, 5), ('Hangar', 25, 1, 34, 5), ('Armory', 1, 7, 8, 12), ('Hub', 13, 7, 22, 12),
                ('Comms', 27, 7, 34, 12), ('Quarters', 1, 14, 10, 18), ('Engine', 25, 14, 34, 18)],
               [(11, 3, 24, 3), (17, 4, 17, 6), (9, 9, 12, 9), (23, 9, 26, 9), (4, 6, 4, 6), (30, 6, 30, 6), (4, 13, 4, 13),
                (30, 13, 30, 13), (17, 13, 17, 16), (11, 16, 24, 16)],
               {'V': [(17, 9)], 'T': [(2, 8), (14, 8), (28, 8), (6, 15), (33, 3), (27, 16), (8, 3), (21, 11), (33, 11), (2, 17)],
                'D': [(7, 11), (26, 2), (9, 17), (31, 17)], 'F': [(33, 17), (5, 2)], 'G': [(2, 12), (28, 11)],
                'R': [(26, 15), (2, 2)], 'L': [(3, 15)], 'A': [(20, 8)], 'Q': [(32, 8)],
                'a': [(9, 5), (3, 9), (9, 15)], 'b': [(34, 5), (34, 12), (26, 17)], 'c': [(14, 11), (21, 8)]})
      ]

      DIRS = {1: (0, -1), 2: (0, 1), 3: (-1, 0), 4: (1, 0)}
      LOBBY, PLAY, MEET, END = 0, 1, 2, 3
      CREW, IMP, ENG, SCI, GRD = 0, 1, 2, 3, 4
      ROLE_NAME = {CREW: 'CREW', IMP: 'IMPOSTOR', ENG: 'ENGINEER', SCI: 'SCIENTIST', GRD: 'GUARDIAN'}
      ROLE_HELP = {CREW: 'do tasks (E)', IMP: 'kill K, vent V, sabotage Z/X', ENG: 'tasks + vent V (3 hops) + F = remote sabotage fix (1x)',
                   SCI: 'tasks + vitals: you see who is dead', GRD: 'tasks + F = shield nearest player (blocks 1 kill)'}
      T_STATE, T_INPUT, T_ROLE = 1, 2, 3
      BCAST, MAGIC, SKIP = 255, 0xA0, 0xFE
      MAXP = 16
      TASK_NAME = {'T': 'Wiring', 'D': 'Download (E x3, stay)', 'F': 'Fuel engine (take gas G first)'}


      def bfs_dir(mp, src, dst):
          if src == dst:
              return 0
          q, seen = deque([(src, 0)]), {src}
          while q:
              (x, y), first = q.popleft()
              for d, (dx, dy) in DIRS.items():
                  n = (x + dx, y + dy)
                  if n in seen or not mp.free(*n):
                      continue
                  if n == dst:
                      return first or d
                  seen.add(n)
                  q.append((n, first or d))
          return 0


      # ---------------- security / framing ----------------
      def _ks(key, hdr, n):
          out, c = b'', 0
          while len(out) < n:
              out += hashlib.sha256(key + hdr + bytes([c])).digest()
              c += 1
          return out[:n]


      def seal(key, typ, sender, dest, seq, payload):
          hdr = bytes([MAGIC | typ, sender, dest]) + struct.pack('!H', seq & 0xFFFF)
          ct = bytes(a ^ b for a, b in zip(payload, _ks(key, hdr, len(payload))))
          return hdr + ct + hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4]


      def unseal(key, raw):
          if len(raw) < 9 or (raw[0] & 0xF0) != MAGIC:
              return None
          hdr, ct, mac = raw[:5], raw[5:-4], raw[-4:]
          if not hmac.compare_digest(hmac.new(key, hdr + ct, hashlib.sha256).digest()[:4], mac):
              return None
          pt = bytes(a ^ b for a, b in zip(ct, _ks(key, hdr, len(ct))))
          return hdr[0] & 0x0F, hdr[1], hdr[2], struct.unpack('!H', hdr[3:5])[0], pt


      def newer(seq, last):
          return last is None or 0 < ((seq - last) & 0xFFFF) < 0x8000


      # ---------------- authoritative game core (host only) ----------------
      class Core:
          def __init__(s, n, rng=None, kill_cd=8.0, meet_s=15.0, sab_cd=20.0, react_s=30.0, map_pref=0):
              s.n, s.rng, s.kill_cd, s.meet_s = n, rng or random.Random(), kill_cd, meet_s
              s.sab_cd, s.react_s, s.map_pref = sab_cd, react_s, map_pref
              s.mapid = 0
              s.lobby()

          @property
          def mp(s):
              return MAPS[s.mapid]

          def lobby(s):
              n = s.n
              s.phase, s.winner, s.done, s.active, s.eject = LOBBY, 0, 0, 0, 255
              s.imps, s.role = set(), [-1] * n
              s.inplay, s.alive, s.body = [0] * n, [1] * n, [0] * n
              s.dir, s.vote = [0] * n, [0] * n
              s.sp = list(s.mp.spawns)
              s.pos = [s.spawn(i) for i in range(n)]
              s.meet_end = s.sab_ready = 0
              s.kill_ready = [0.0] * n
              s.dl, s.fuel, s.shield = [[-1, 0] for _ in range(n)], [0] * n, [0] * n
              s.ventl, s.engfix, s.btn = [0] * n, [0] * n, [0] * n
              s.lights, s.react_end, s.rpanel = 0, 0.0, {}

          def spawn(s, i):
              return s.sp[i % len(s.sp)]

          def start(s, now, present):
              ids = [i for i in range(s.n) if present[i]]
              if len(ids) < 3:
                  return False
              s.lobby()
              mid = s.map_pref - 1 if 1 <= s.map_pref <= len(MAPS) else s.rng.randrange(len(MAPS))
              s.mapid = mid
              s.sp = list(s.mp.spawns)
              s.rng.shuffle(s.sp)
              s.pos = [s.spawn(i) for i in range(s.n)]
              s.phase = PLAY
              for i in ids:
                  s.inplay[i] = 1
              s.alive = [1 if s.inplay[i] else 0 for i in range(s.n)]
              order = ids[:]
              s.rng.shuffle(order)
              ni = 2 if len(ids) >= 7 else 1
              s.imps = set(order[:ni])
              crew = order[ni:]
              for i in ids:
                  s.role[i] = IMP if i in s.imps else CREW
              for r, need in ((ENG, 4), (SCI, 5), (GRD, 6)):
                  if len(ids) >= need and crew:
                      s.role[crew.pop()] = r
              for i in ids:
                  if s.role[i] == ENG:
                      s.ventl[i], s.engfix[i] = 3, 1
                  if i in s.imps:
                      s.kill_ready[i] = now + s.kill_cd
              ncrew = len(ids) - ni
              k = min(len(s.mp.tasks), max(5, 2 * ncrew + 2))
              for t in s.rng.sample(range(len(s.mp.tasks)), k):
                  s.active |= 1 << t
              s.sab_ready = now + s.sab_cd
              return True

          def end(s, w):
              s.phase, s.winner = END, w

          def check(s):
              crew = [i for i in range(s.n) if s.inplay[i] and s.alive[i] and i not in s.imps]
              imps = [i for i in s.imps if s.alive[i]]
              if not imps:
                  s.end(1)
              elif len(crew) <= len(imps):
                  s.end(2)

          def step(s, now):
              if s.phase == PLAY:
                  for i in range(s.n):
                      if s.inplay[i] and s.alive[i] and s.dir[i] in DIRS:
                          dx, dy = DIRS[s.dir[i]]
                          x, y = s.pos[i]
                          if s.mp.free(x + dx, y + dy):
                              s.pos[i] = (x + dx, y + dy)
                      t = s.dl[i][0]
                      if t >= 0 and s.pos[i] != s.mp.tasks[t][:2]:
                          s.dl[i] = [-1, 0]
                  if s.react_end and now >= s.react_end:
                      s.end(2)
              elif s.phase == MEET:
                  voters = [i for i in range(s.n) if s.inplay[i] and s.alive[i]]
                  if now >= s.meet_end or all(s.vote[i] for i in voters):
                      s.tally(now)

          def _use(s, p, x, y, now):
              mp, ch = s.mp, s.mp.at(x, y)
              if ch in 'TDF' and (x, y) in mp.tpos:
                  k = mp.tpos[(x, y)]
                  if not (s.active >> k & 1) or (s.done >> k & 1):
                      return
                  ok = False
                  if ch == 'T':
                      ok = True
                  elif ch == 'D':
                      s.dl[p] = [k, s.dl[p][1] + 1] if s.dl[p][0] == k else [k, 1]
                      if s.dl[p][1] >= 3:
                          ok, s.dl[p] = True, [-1, 0]
                  elif ch == 'F' and s.fuel[p]:
                      ok, s.fuel[p] = True, 0
                  if ok:
                      s.done |= 1 << k
                      if s.done & s.active == s.active:
                          s.end(1)
              elif ch == 'G':
                  s.fuel[p] = 1
              elif ch == 'L' and s.lights:
                  s.lights = 0
              elif ch == 'R' and s.react_end:
                  s.rpanel[(x, y)] = now
                  if all(now - s.rpanel.get(q, -99) <= 4.0 for q in mp.panels):
                      s.react_end, s.rpanel = 0.0, {}

          def act(s, p, a, now):
              if s.phase != PLAY or not s.inplay[p] or not s.alive[p]:
                  return
              x, y = s.pos[p]
              imp, role = p in s.imps, s.role[p]
              if a & 1 and not imp:
                  s._use(p, x, y, now)
                  if s.phase != PLAY:
                      return
              if a & 2 and imp and now >= s.kill_ready[p]:
                  best = None
                  for q in range(s.n):
                      if q != p and s.inplay[q] and s.alive[q] and q not in s.imps:
                          d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                          if d <= 2 and (best is None or d < best[0]):
                              best = (d, q)
                  if best:
                      q = best[1]
                      if s.shield[q]:
                          s.shield[q], s.kill_ready[p] = 0, now + 4.0
                      else:
                          s.alive[q], s.body[q], s.kill_ready[p] = 0, 1, now + s.kill_cd
                          s.check()
                          if s.phase != PLAY:
                              return
              if a & 4:
                  near = any(s.body[q] and abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y) <= 2 for q in range(s.n))
                  btn = (x, y) == s.mp.button and not s.btn[p] and not s.react_end
                  if near or btn:
                      if not near:
                          s.btn[p] = 1
                      s.phase, s.meet_end, s.vote, s.eject = MEET, now + s.meet_s, [0] * s.n, 255
                      s.body, s.dir = [0] * s.n, [0] * s.n
                      s.pos = [s.spawn(i) for i in range(s.n)]
                      s.dl = [[-1, 0] for _ in range(s.n)]
                      return
              if a & 8 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.lights, s.sab_ready = 1, now + s.sab_cd
              if a & 0x40 and imp and now >= s.sab_ready and not s.lights and not s.react_end:
                  s.react_end, s.rpanel, s.sab_ready = now + s.react_s, {}, now + s.sab_cd + s.react_s
              if a & 16 and (imp or (role == ENG and s.ventl[p] > 0)) and (x, y) in s.mp.vent:
                  s.pos[p] = s.mp.vent[(x, y)]
                  if not imp:
                      s.ventl[p] -= 1
              if a & 32:
                  if role == ENG and s.engfix[p] > 0 and (s.lights or s.react_end):
                      s.lights, s.react_end, s.rpanel, s.engfix[p] = 0, 0.0, {}, 0
                  elif role == GRD:
                      best = None
                      for q in range(s.n):
                          if q != p and s.inplay[q] and s.alive[q]:
                              d = abs(s.pos[q][0] - x) + abs(s.pos[q][1] - y)
                              if d <= 3 and (best is None or d < best[0]):
                                  best = (d, q)
                      if best:
                          s.shield = [0] * s.n
                          s.shield[best[1]] = 1

          def set_vote(s, p, v):
              if s.phase == MEET and s.inplay[p] and s.alive[p]:
                  if v == SKIP or (1 <= v <= s.n and s.inplay[v - 1] and s.alive[v - 1]):
                      s.vote[p] = v

          def tally(s, now):
              cnt = {}
              for i in range(s.n):
                  if s.inplay[i] and s.alive[i] and s.vote[i]:
                      cnt[s.vote[i]] = cnt.get(s.vote[i], 0) + 1
              top = sorted(cnt.items(), key=lambda kv: -kv[1])
              s.eject = 254
              if top and (len(top) == 1 or top[0][1] > top[1][1]) and top[0][0] != SKIP:
                  q = top[0][0] - 1
                  s.alive[q], s.eject = 0, q
                  s.check()
                  if s.phase == END:
                      return
              s.phase, s.vote, s.dir = PLAY, [0] * s.n, [0] * s.n
              for i in s.imps:
                  s.kill_ready[i] = now + s.kill_cd
              s.sab_ready = now + s.sab_cd
              s.lights, s.react_end, s.rpanel, s.shield = 0, 0.0, {}, [0] * s.n
              s.pos = [s.spawn(i) for i in range(s.n)]

          def view(s, present, now, acks):
              pl = []
              for i in range(s.n):
                  fl = s.alive[i] | ((1 if (s.inplay[i] or present[i]) else 0) << 1) | (s.body[i] << 2) | ((1 if s.vote[i] else 0) << 3)
                  aux = (s.dl[i][1] & 3) | (s.fuel[i] << 2) | (s.shield[i] << 3) | ((s.ventl[i] & 3) << 4) | ((1 if s.engfix[i] else 0) << 6)
                  pl.append((s.pos[i][0], s.pos[i][1], fl, acks[0][i], acks[1][i], aux))
              kl = [s.kill_ready[i] - now for i in s.imps if s.alive[i]]
              mask = sum(1 << i for i in s.imps) if s.phase == END else 0
              return dict(phase=s.phase, winner=s.winner, done=s.done, active=s.active,
                          meet_left=int(max(0, s.meet_end - now)) if s.phase == MEET else 0,
                          n=s.n, mapid=s.mapid, reveal=mask, eject=s.eject,
                          flags=(1 if s.lights else 0) | (2 if s.react_end else 0),
                          sab_left=int(max(0, s.react_end - now)) if s.react_end else 0,
                          sab_cd=int(min(255, max(0, s.sab_ready - now))) if s.phase == PLAY else 0,
                          kill_left=int(min(255, max(0, min(kl)))) if (kl and s.phase == PLAY) else 0, players=pl)


      HDR = '!BBHHBBBHBBBBBBBB'


      def pack_state(v, chat):
          cid, cfrom, ctext = chat
          out = struct.pack(HDR, v['phase'], v['winner'], v['done'], v['active'], v['meet_left'], v['n'], v['mapid'],
                            v['reveal'], v['eject'], v['flags'], v['sab_left'], v['sab_cd'], v['kill_left'], cid, cfrom, len(ctext)) + ctext
          for x, y, fl, ca, ha, ax in v['players']:
              out += struct.pack('!BBBBBB', x, y, fl, ca, ha, ax)
          return out


      def unpack_state(pt):
          hs = struct.calcsize(HDR)
          ph, win, dn, ac, ml, n, mid, rev, ej, fg, sl, sc, kl, cid, cf, cl = struct.unpack(HDR, pt[:hs])
          text, o, pl = pt[hs:hs + cl], hs + cl, []
          for i in range(n):
              pl.append(struct.unpack('!BBBBBB', pt[o + 6 * i:o + 6 * i + 6]))
          return dict(phase=ph, winner=win, done=dn, active=ac, meet_left=ml, n=n, mapid=mid, reveal=rev, eject=ej, flags=fg,
                      sab_left=sl, sab_cd=sc, kill_left=kl, players=pl), (cid, cf, text)


      # ---------------- GNU Radio block ----------------
      class blk(gr.basic_block):
          def __init__(self, node_id=0, n_players=4, tick_ms=250, slot_ms=45, guard_ms=70,
                       key='change-this-game-key', show_gui=1, bot=0, min_players=3, title='Among Us Lite', map_pref=0):
              gr.basic_block.__init__(self, name="Among Us Lite Node", in_sig=None, out_sig=None)
              self.me, self.n = int(node_id), min(MAXP, max(3, int(n_players)))
              self.host = self.me == 0
              # TDMA frame must fit every client slot: stretch the tick automatically for big lobbies (same maths on every node)
              tick_ms = max(float(tick_ms), float(guard_ms) + (self.n - 1) * float(slot_ms) + 30.0)
              self.tick, self.slot, self.guard = tick_ms / 1000.0, slot_ms / 1000.0, guard_ms / 1000.0
              self.key = str(key).encode()
              self.show_gui, self.bot, self.title = bool(show_gui), bool(bot), str(title)
              self.map_pref = int(map_pref)
              self.lk = threading.RLock()
              self.running, self.seq, self.win = False, 0, None
              self.dirv, self.pending, self.myvote, self.start_req = 0, 0, 0, False
              self.chat_log, self.chat_out, self.cur_chat, self.last_chat_id = [], deque(), (0, b''), 0
              self.role, self.partners, self.view, self.t_state, self.prev, self.rng = None, 0, None, 0.0, {}, random.Random()
              self.cmd_id, self.bot_t, self.fail = 0, 0, 0
              if self.host:
                  self.core, self.last_rx = Core(self.n, map_pref=self.map_pref), [0.0] * self.n
                  self.cmd_seen, self.chat_seen, self.roleack = [0] * self.n, [0] * self.n, [0] * self.n
                  self.seq_in, self.hchat, self.chat_id, self.chat_cur, self.rr = [None] * self.n, deque(), 0, (0, 0, b''), 0
              else:
                  self.last_state_seq = None
              self._bridge = None
              if self.show_gui:
                  try:  # object created on the main (Qt) thread; its signal is queued to that thread
                      from PyQt5 import QtCore
                      if QtCore.QCoreApplication.instance() is not None:
                          class _Bridge(QtCore.QObject):
                              go = QtCore.pyqtSignal()
                          self._bridge = _Bridge()
                          self._bridge.go.connect(self._build_gui_safe)
                  except Exception as e:
                      print("game GUI bridge unavailable:", e)
              self.message_port_register_in(pmt.intern("rx_in"))
              self.message_port_register_out(pmt.intern("tx_out"))
              self.set_msg_handler(pmt.intern("rx_in"), self.handle_rx)

          # ---- lifecycle ----
          def start(self):
              self.running = True
              if self.host:
                  threading.Thread(target=self._host_loop, daemon=True).start()
              if self.show_gui:
                  if self._bridge is not None:
                      self._bridge.go.emit()
                  else:
                      self._build_gui_safe()
              return True

          def _build_gui_safe(self):
              try:
                  self._build_gui()
              except Exception as e:
                  print("game GUI disabled:", repr(e))

          def stop(self):
              self.running = False
              return True

          # ---- radio I/O ----
          def _send(self, typ, dest, payload):
              self.seq = (self.seq + 1) & 0xFFFF
              raw = seal(self.key, typ, self.me, dest, self.seq, payload)
              self.message_port_pub(pmt.intern("tx_out"), pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(raw), list(raw))))

          def handle_rx(self, msg):
              try:
                  if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                      return
                  r = unseal(self.key, bytes(pmt.u8vector_elements(pmt.cdr(msg))))
                  if r is None:
                      self.fail += 1
                      return
                  typ, snd, dst, seq, pt = r
                  now = time.time()
                  if snd == self.me:
                      return
                  with self.lk:
                      if self.host and typ == T_INPUT and 0 < snd < self.n and dst == 0:
                          if newer(seq, self.seq_in[snd]):
                              self.seq_in[snd] = seq
                              self._on_input(snd, pt, now)
                      elif (not self.host) and snd == 0 and dst in (BCAST, self.me):
                          if typ == T_STATE and newer(seq, self.last_state_seq):
                              self.last_state_seq = seq
                              self._on_state(pt, now)
                          elif typ == T_ROLE and dst == self.me:
                              self.role = pt[0]
                              self.partners = struct.unpack('!H', pt[1:3])[0] if len(pt) >= 3 else 0
              except Exception as e:
                  print("game rx error:", repr(e))

          # ---- host ----
          def _on_input(self, p, pt, now):
              c = self.core
              d, cmd, act, vote, cid, cl = struct.unpack('!BBBBBB', pt[:6])
              text = pt[6:6 + cl]
              self.last_rx[p] = now
              c.dir[p] = d if d in DIRS else 0
              if act & 0x80:
                  self.roleack[p] = 1
              if (act & 0x7F) and cmd != self.cmd_seen[p]:
                  c.act(p, act & 0x7F, now)
              self.cmd_seen[p] = cmd
              c.set_vote(p, vote)
              if cid and cid != self.chat_seen[p]:
                  self.hchat.append((p, text[:20]))
                  self.chat_seen[p] = cid

          def _host_loop(self):
              nxt = time.time()
              while self.running:
                  now = time.time()
                  if now >= nxt:
                      nxt = max(nxt + self.tick, now + self.tick * 0.5)
                      try:
                          self._host_tick(now)
                      except Exception as e:
                          print("host tick error:", repr(e))
                  time.sleep(0.002)

          def _host_tick(self, now):
              with self.lk:
                  c = self.core
                  c.map_pref = self.map_pref
                  present = [1 if (i == 0 or now - self.last_rx[i] < 3.0) else 0 for i in range(self.n)]
                  if self.bot:
                      self._bot(self.view_host(present, now), now, present)
                  if self.start_req:
                      self.start_req = False
                      if c.phase in (LOBBY, END):
                          if c.phase == END:
                              c.lobby()
                          elif c.start(now, present):
                              self.roleack = [1 if i == 0 else 0 for i in range(self.n)]
                              self.role = c.role[0] if c.role[0] >= 0 else None
                              self.partners = sum(1 << i for i in c.imps) if c.role[0] == IMP else 0
                  c.dir[0] = self.dirv
                  if self.pending:
                      c.act(0, self.pending & 0x7F, now)
                      self.pending = 0
                  if c.phase == MEET:
                      c.set_vote(0, self.myvote)
                  for i in range(1, self.n):
                      if not present[i]:
                          c.dir[i] = 0
                  c.step(now)
                  if c.phase != MEET:
                      self.myvote = 0
                  if c.phase == LOBBY:
                      self.role, self.partners = None, 0
                  if self.hchat:
                      self.chat_id = self.chat_id % 255 + 1
                      f, t = self.hchat.popleft()
                      self.chat_cur = (self.chat_id, f, t)
                      self._log(f, t)
                  v = self.view_host(present, now)
                  self._set_view(v, now)
                  self._send(T_STATE, BCAST, pack_state(v, self.chat_cur))
                  if c.phase == PLAY:
                      for k in range(1, self.n):
                          p = 1 + (self.rr + k - 1) % (self.n - 1)
                          if c.inplay[p] and not self.roleack[p]:
                              self.rr = p
                              pm = sum(1 << i for i in c.imps) if p in c.imps else 0
                              self._send(T_ROLE, p, bytes([c.role[p]]) + struct.pack('!H', pm))
                              break

          def view_host(self, present, now):
              return self.core.view(present, now, (self.cmd_seen, self.chat_seen))

          # ---- client ----
          def _on_state(self, pt, now):
              v, chat = unpack_state(pt)
              self._set_view(v, now)
              cid, cf, text = chat
              if cid and cid != self.last_chat_id:
                  self.last_chat_id = cid
                  self._log(cf, text)
              if v['phase'] == LOBBY:
                  self.role, self.partners = None, 0
              if v['phase'] != MEET:
                  self.myvote = 0
              me = v['players'][self.me] if self.me < len(v['players']) else None
              if me:
                  if me[3] == self.cmd_id:
                      self.pending = 0
                  if self.cur_chat[0] and me[4] == self.cur_chat[0]:
                      self.cur_chat = (0, b'')
              if self.bot:
                  self._bot(v, now, None)
              delay = self.guard + (self.me - 1) * self.slot
              t = threading.Timer(delay, self._client_send)
              t.daemon = True
              t.start()

          def _client_send(self):
              if not self.running:
                  return
              with self.lk:
                  if not self.cur_chat[0] and self.chat_out:
                      nid = self.cur_chat_id = (getattr(self, 'cur_chat_id', 0) % 255) + 1
                      self.cur_chat = (nid, self.chat_out.popleft()[:20])
                  cid, ct = self.cur_chat
                  act = (self.pending & 0x7F) | (0x80 if self.role is not None else 0)
                  pl = struct.pack('!BBBBBB', self.dirv, self.cmd_id, act, self.myvote, cid, len(ct)) + ct
              self._send(T_INPUT, 0, pl)

          # ---- shared helpers ----
          def mp(self):
              return MAPS[self.view['mapid'] % len(MAPS)] if self.view else MAPS[0]

          def _set_view(self, v, now):
              old = self.view
              if old and old['mapid'] == v['mapid'] and len(old['players']) == len(v['players']):
                  self.prev = {i: self.display_pos(i, now) for i in range(len(old['players']))}
              else:
                  self.prev = {}
              self.view, self.t_state = v, now

          def display_pos(self, i, now):
              v = self.view
              if not v or i >= len(v['players']):
                  return (0, 0)
              x, y = v['players'][i][0], v['players'][i][1]
              px, py = self.prev.get(i, (x, y))
              if abs(px - x) + abs(py - y) > 3:  # vent hop / meeting respawn: snap
                  return (x, y)
              a = min(1.0, (now - self.t_state) / max(self.tick, 0.01))
              return (px + (x - px) * a, py + (y - py) * a)

          def _log(self, who, text):
              try:
                  s = text.decode('utf-8', 'replace')
              except Exception:
                  s = '?'
              self.chat_log.append("P%d: %s" % (who + 1, s))
              del self.chat_log[:-60]

          def request_action(self, bit):
              with self.lk:
                  if self.host:
                      self.pending = bit
                  elif not self.pending:
                      self.cmd_id = self.cmd_id % 255 + 1
                      self.pending = bit

          def send_chat(self, text):
              t = text.encode('utf-8')[:20]
              with self.lk:
                  if self.host:
                      self.hchat.append((0, t))
                  else:
                      self.chat_out.append(t)

          def cast_vote(self, v):
              with self.lk:
                  self.myvote = v

          def _bot(self, v, now, present):
              if now - self.bot_t < self.tick * 0.9:
                  return
              self.bot_t = now
              ph, me, mp = v['phase'], self.me, self.mp()
              pl = v['players']
              if ph == LOBBY:
                  if self.host and present is not None and sum(present) >= self.min_players_n() and now - self.t0() > 1.5:
                      self.start_req = True
                  return
              if ph == END:
                  if self.host and now - self.t_end(now) > 3:
                      self.start_req = True
                  return
              mypos, alive = (pl[me][0], pl[me][1]), pl[me][2] & 1
              if ph == MEET:
                  if alive and not self.myvote:
                      cands = [i + 1 for i in range(v['n']) if pl[i][2] & 1 and i != me and not (self.partners >> i & 1)]
                      self.cast_vote(self.rng.choice(cands + [SKIP]))
                  return
              self.dirv = 0
              if not alive:
                  return
              dist = lambda a, b: abs(a[0] - b[0]) + abs(a[1] - b[1])
              if self.role == IMP:
                  tg = [(dist(p, mypos), i) for i, p in enumerate(pl)
                        if i != me and p[2] & 1 and p[2] & 2 and not (self.partners >> i & 1)]
                  if v['sab_cd'] == 0 and not v['flags'] and self.rng.random() < 0.03:
                      self.request_action(8 if self.rng.random() < 0.7 else 0x40)
                  if tg:
                      d, i = min(tg)
                      if d <= 2 and self.rng.random() < 0.5:
                          self.request_action(2)
                      self.dirv = bfs_dir(mp, mypos, (pl[i][0], pl[i][1]))
              else:
                  if v['flags'] & 2:
                      tgt = min(mp.panels, key=lambda t: dist(t, mypos))
                      if mypos == tgt:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tgt)
                      return
                  if v['flags'] & 1:
                      lp = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'L'][0]
                      if mypos == lp:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, lp)
                      return
                  todo = [t for k, t in enumerate(mp.tasks) if v['active'] >> k & 1 and not v['done'] >> k & 1]
                  if todo:
                      fuel = pl[me][5] >> 2 & 1
                      if not fuel and any(t[2] == 'F' for t in todo):
                          gs = [(x, y) for y in range(mp.H) for x in range(mp.W) if mp.g[y][x] == 'G']
                          todo = [min(gs, key=lambda g: dist(g, mypos)) + ('G',)]
                      else:
                          todo = [t for t in todo if t[2] != 'F' or fuel]
                      tg = min(todo, key=lambda t: dist(t, mypos))
                      if mypos == tg[:2]:
                          self.request_action(1)
                      else:
                          self.dirv = bfs_dir(mp, mypos, tg[:2])
                  bodies = [dist(p, mypos) for p in pl if p[2] & 4]
                  if bodies and min(bodies) <= 2:
                      self.request_action(4)

          def min_players_n(self):
              return 3

          def t0(self):
              if not hasattr(self, '_t0'):
                  self._t0 = time.time()
              return self._t0

          def t_end(self, now):
              if not hasattr(self, '_te') or self._te_phase != END:
                  self._te, self._te_phase = now, END
              return self._te

          # ---- Qt GUI ----
          def _build_gui(self):
              from PyQt5 import QtCore, QtGui, QtWidgets
              if QtWidgets.QApplication.instance() is None:
                  return
              node = self
              COL = ['#e53935', '#1e88e5', '#43a047', '#fdd835', '#8e24aa', '#fb8c00', '#00acc1', '#6d4c41',
                     '#ec407a', '#9ccc65', '#26a69a', '#7e57c2', '#ffa726', '#8d6e63', '#78909c', '#d4e157']
              TINT = ['#c9ccd3', '#c3d0d8', '#d3cbc3', '#c8d5c6', '#d0c6d6', '#d6d2bd']
              SC = {'T': '#f9a825', 'D': '#29b6f6', 'F': '#ff7043', 'G': '#8d6e63', 'R': '#ef5350', 'L': '#fff176',
                    'A': '#26a69a', 'Q': '#26c6da', 'V': '#d32f2f'}

              class Board(QtWidgets.QWidget):
                  def __init__(s):
                      super().__init__()
                      s.setMinimumSize(760, 420)
                      s.setFocusPolicy(QtCore.Qt.StrongFocus)

                  def paintEvent(s, _):
                      p = QtGui.QPainter(s)
                      p.setRenderHint(QtGui.QPainter.Antialiasing)
                      now = time.time()
                      p.fillRect(s.rect(), QtGui.QColor('#10141c'))
                      with node.lk:
                          v = node.view
                          mp = node.mp()
                          W, H = mp.W, mp.H
                          cs = min(s.width() / W, s.height() / H)
                          me = node.me
                          mepl = v['players'][me] if v and me < len(v['players']) else None
                          ingame = bool(v and v['phase'] in (PLAY, MEET))
                          mealive = bool(mepl and mepl[2] & 1)
                          lights = bool(v and v['flags'] & 1)
                          imp = node.role == IMP
                          mx, my = node.display_pos(me, now) if mepl else (0, 0)
                          R = 8.5 if imp else (2.6 if lights else 6.5)
                          x_i, y_i = (int(round(mx)), int(round(my)))
                          god = (not ingame) or (not mealive) or (mp.at(x_i, y_i) in 'AQ')
                          f = p.font()
                          f.setPixelSize(max(8, int(cs * .45)))
                          p.setFont(f)
                          for y in range(H):
                              for x in range(W):
                                  ch = mp.g[y][x]
                                  if ch == '#':
                                      col = '#2b3340'
                                  else:
                                      k = mp.col[y][x]
                                      col = TINT[k % len(TINT)] if k >= 0 else '#aeb2ba'
                                  p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(col))
                                  if ch in SC:
                                      inner, c = .6, SC[ch]
                                      if ch in 'TDF':
                                          kk = mp.tpos[(x, y)]
                                          if v and not v['active'] >> kk & 1:
                                              c = '#9aa0a6'
                                          elif v and v['done'] >> kk & 1:
                                              c = '#43a047'
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .2, y * cs + cs * .2, cs * inner, cs * inner), QtGui.QColor(c))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  elif ch in 'abcdef':
                                      p.fillRect(QtCore.QRectF(x * cs + cs * .1, y * cs + cs * .3, cs * .8, cs * .4), QtGui.QColor('#3a2f2f'))
                                      p.setPen(QtGui.QColor('#bbbbbb'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, ch)
                                  if ingame and not god and ch != '#' and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      p.fillRect(QtCore.QRectF(x * cs, y * cs, cs, cs), QtGui.QColor(0, 0, 0, 175))
                          p.setPen(QtGui.QColor(20, 20, 20, 170))
                          for nm, x0, y0, x1, y1 in mp.rooms:
                              p.drawText(QtCore.QRectF(x0 * cs, y0 * cs, (x1 - x0 + 1) * cs, cs * .9), QtCore.Qt.AlignCenter, nm)
                          if v:
                              for i, pl in enumerate(v['players']):
                                  if not pl[2] & 2:
                                      continue
                                  x, y = node.display_pos(i, now)
                                  if i != me and not god and (x - mx) ** 2 + (y - my) ** 2 > R * R:
                                      continue
                                  c = QtGui.QColor(COL[i % 16])
                                  if pl[2] & 1:
                                      p.setBrush(c)
                                      partner = bool(imp and node.partners >> i & 1 and i != me)
                                      pen = QtGui.QColor('#ff1744') if partner else QtGui.QColor('white' if i == me else 'black')
                                      p.setPen(QtGui.QPen(pen, 3 if (i == me or partner) else 1))
                                      p.drawEllipse(QtCore.QRectF(x * cs + cs * .12, y * cs + cs * .12, cs * .76, cs * .76))
                                      if node.role == GRD and pl[5] >> 3 & 1:
                                          p.setBrush(QtCore.Qt.NoBrush)
                                          p.setPen(QtGui.QPen(QtGui.QColor('#4fc3f7'), 2))
                                          p.drawEllipse(QtCore.QRectF(x * cs, y * cs, cs, cs))
                                      p.setPen(QtGui.QColor('black'))
                                      p.drawText(QtCore.QRectF(x * cs, y * cs, cs, cs), QtCore.Qt.AlignCenter, str(i + 1))
                                  elif pl[2] & 4:
                                      p.setPen(QtGui.QPen(c, 4))
                                      p.drawLine(QtCore.QPointF(x * cs + 6, y * cs + 6), QtCore.QPointF(x * cs + cs - 6, y * cs + cs - 6))
                                      p.drawLine(QtCore.QPointF(x * cs + cs - 6, y * cs + 6), QtCore.QPointF(x * cs + 6, y * cs + cs * 1 - 6))
                          if v and v['flags'] & 2:
                              p.fillRect(QtCore.QRectF(0, 0, s.width(), 26), QtGui.QColor(200, 30, 30, 200))
                              p.setPen(QtGui.QColor('white'))
                              p.drawText(QtCore.QRectF(0, 0, s.width(), 26), QtCore.Qt.AlignCenter,
                                         "REACTOR MELTDOWN in %ds - two crew must press E on both red R panels within 4 s!" % v['sab_left'])
                      p.end()

                  KEYS = {QtCore.Qt.Key_Up: 1, QtCore.Qt.Key_W: 1, QtCore.Qt.Key_Down: 2, QtCore.Qt.Key_S: 2,
                          QtCore.Qt.Key_Left: 3, QtCore.Qt.Key_A: 3, QtCore.Qt.Key_Right: 4, QtCore.Qt.Key_D: 4}

                  def keyPressEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      Q = QtCore.Qt
                      if k:
                          held.append(k)
                          node.dirv = k
                      elif e.key() == Q.Key_E:
                          node.request_action(1)
                      elif e.key() == Q.Key_K:
                          node.request_action(2)
                      elif e.key() == Q.Key_R:
                          node.request_action(4)
                      elif e.key() == Q.Key_Z:
                          node.request_action(8)
                      elif e.key() == Q.Key_X:
                          node.request_action(0x40)
                      elif e.key() == Q.Key_V:
                          node.request_action(16)
                      elif e.key() == Q.Key_F:
                          node.request_action(32)
                      elif Q.Key_1 <= e.key() <= Q.Key_9:
                          node.cast_vote(e.key() - Q.Key_0)

                  def keyReleaseEvent(s, e):
                      if e.isAutoRepeat():
                          return
                      k = s.KEYS.get(e.key())
                      if k in held:
                          held.remove(k)
                      node.dirv = held[-1] if held else 0

              held = []
              w = QtWidgets.QWidget()
              w.setWindowTitle("%s - %s" % (node.title, "HOST" if node.host else "Player %d" % (node.me + 1)))
              board = Board()
              status = QtWidgets.QLabel("")
              status.setWordWrap(True)
              plist = QtWidgets.QListWidget()
              tasks_lbl = QtWidgets.QLabel("")
              tasks_lbl.setStyleSheet("font-family: monospace; font-size: 11px")
              tasks_lbl.setAlignment(QtCore.Qt.AlignTop)
              chat = QtWidgets.QTextEdit()
              chat.setReadOnly(True)
              line = QtWidgets.QLineEdit()
              line.setPlaceholderText("chat (20 chars), Enter to send; Esc = back to map")
              btns = QtWidgets.QHBoxLayout()
              bt = {}
              for key, label, fn in [("use", "Use [E]", lambda: node.request_action(1)),
                                     ("kill", "Kill [K]", lambda: node.request_action(2)),
                                     ("report", "Report/Button [R]", lambda: node.request_action(4)),
                                     ("lights", "Lights out [Z]", lambda: node.request_action(8)),
                                     ("reactor", "Reactor [X]", lambda: node.request_action(0x40)),
                                     ("vent", "Vent [V]", lambda: node.request_action(16)),
                                     ("abil", "Ability [F]", lambda: node.request_action(32)),
                                     ("skip", "Skip vote", lambda: node.cast_vote(SKIP))]:
                  b = QtWidgets.QPushButton(label)
                  b.setFocusPolicy(QtCore.Qt.NoFocus)
                  b.clicked.connect(fn)
                  btns.addWidget(b)
                  bt[key] = b
              if node.host:
                  cb = QtWidgets.QComboBox()
                  cb.addItems(["Map: random"] + ["Map: " + m.name for m in MAPS])
                  cb.setFocusPolicy(QtCore.Qt.NoFocus)
                  cb.currentIndexChanged.connect(lambda i: setattr(node, 'map_pref', i))
                  btns.addWidget(cb)
                  sb = QtWidgets.QPushButton("START / NEW ROUND")
                  sb.setFocusPolicy(QtCore.Qt.NoFocus)
                  sb.clicked.connect(lambda: setattr(node, 'start_req', True))
                  btns.addWidget(sb)
              side = QtWidgets.QVBoxLayout()
              plbl = QtWidgets.QLabel("Players")
              for x in (plbl, plist, tasks_lbl, chat, line):
                  side.addWidget(x)
              plist.setMaximumHeight(210)
              top = QtWidgets.QHBoxLayout()
              top.addWidget(board, 3)
              top.addLayout(side, 1)
              lay = QtWidgets.QVBoxLayout(w)
              lay.addWidget(status)
              lay.addLayout(top)
              lay.addLayout(btns)
              line.returnPressed.connect(lambda: (node.send_chat(line.text()), line.clear()))
              plist.setFocusPolicy(QtCore.Qt.NoFocus)
              plist.itemClicked.connect(lambda it: node.cast_vote(plist.row(it) + 1))
              esc = QtWidgets.QShortcut(QtGui.QKeySequence("Esc"), w)
              esc.activated.connect(board.setFocus)
              names = ["LOBBY", "PLAYING", "MEETING", "GAME OVER"]

              def tick():
                  with node.lk:
                      v = node.view
                      if v:
                          mp = node.mp()
                          rl = node.role
                          r = "" if rl is None else "  |  You are %s: %s" % (ROLE_NAME[rl], ROLE_HELP[rl])
                          if rl == IMP and node.partners & ~(1 << node.me):
                              r += "  |  partner(s): " + ",".join("P%d" % (i + 1) for i in range(16) if node.partners >> i & 1 and i != node.me)
                          act_k = [k for k in range(len(mp.tasks)) if v['active'] >> k & 1]
                          dn = sum(1 for k in act_k if v['done'] >> k & 1)
                          t = "%s [%s]%s  |  tasks %d/%d" % (names[v['phase']], mp.name, r, dn, len(act_k))
                          if v['phase'] == PLAY and rl == IMP:
                              t += "  |  kill cd %ds, sabotage cd %ds" % (v['kill_left'], v['sab_cd'])
                          if v['flags'] & 1:
                              t += "  |  LIGHTS OUT: fix at yellow L (E)"
                          mv = "SKIP" if node.myvote == SKIP else ("P%d" % node.myvote if node.myvote else "none yet")
                          mepl = v['players'][node.me] if node.me < len(v['players']) else None
                          me_alive = mepl[2] & 1 if mepl else 0
                          if v['phase'] == MEET:
                              t += (("  |  VOTE NOW (%ds left): click a player in the list, press 1-9, or Skip vote. Your vote: %s" % (v['meet_left'], mv))
                                    if me_alive else "  |  meeting in progress (dead players cannot vote)")
                          if v['phase'] == END:
                              t += "  |  %s WIN (impostor(s): %s)" % ("CREW" if v['winner'] == 1 else "IMPOSTOR",
                                                                    ",".join("P%d" % (i + 1) for i in range(16) if v['reveal'] >> i & 1))
                          if mepl and not me_alive and v['phase'] in (PLAY, MEET):
                              t += "  |  you are DEAD (ghost view)"
                          if mepl and v['phase'] == PLAY:
                              if mepl[5] >> 2 & 1:
                                  t += "  |  carrying FUEL: use it at orange F"
                              if rl == ENG:
                                  t += "  |  vent hops left %d, remote fix %s" % (mepl[5] >> 4 & 3, "ready" if mepl[5] >> 6 & 1 else "used")
                              if mepl[5] & 3:
                                  t += "  |  download %d/3 (stay on the tile, press E)" % (mepl[5] & 3)
                          status.setText(t)
                          playing, meeting = v['phase'] == PLAY and me_alive, v['phase'] == MEET and me_alive
                          bt['use'].setEnabled(bool(playing))
                          bt['kill'].setEnabled(bool(playing and rl == IMP))
                          bt['report'].setEnabled(bool(playing))
                          bt['lights'].setEnabled(bool(playing and rl == IMP))
                          bt['reactor'].setEnabled(bool(playing and rl == IMP))
                          bt['vent'].setEnabled(bool(playing and rl in (IMP, ENG)))
                          bt['abil'].setEnabled(bool(playing and rl in (ENG, GRD)))
                          bt['skip'].setEnabled(bool(meeting))
                          plbl.setText("CLICK A PLAYER TO VOTE FOR THEM" if meeting else "Players")
                          if plist.count() != v['n']:
                              plist.clear()
                              for i in range(v['n']):
                                  plist.addItem("")
                          see_dead = v['phase'] != PLAY or rl == SCI or not me_alive or v['phase'] == END
                          for i, p in enumerate(v['players']):
                              it = plist.item(i)
                              it.setText("%d%s %s%s%s" % (i + 1, " (you)" if i == node.me else "", "" if p[2] & 2 else "[absent] ",
                                                           "" if (p[2] & 1 or not see_dead) else "[dead] ",
                                                           "[voted]" if p[2] & 8 else ("  <== your vote" if (meeting and node.myvote == i + 1) else "")))
                              it.setForeground(QtGui.QColor(COL[i % 16]))
                          lines = []
                          for k in act_k:
                              x, y, c = mp.tasks[k]
                              lines.append("%s %s @ %s" % ("[x]" if v['done'] >> k & 1 else "[ ]", {'T': 'Wiring', 'D': 'Download', 'F': 'Fuel'}[c], mp.room(x, y)))
                          tasks_lbl.setText("TASKS\n" + "\n".join(lines) if lines else "")
                      else:
                          status.setText("waiting for host signal...")
                      txt = "\n".join(node.chat_log)
                  if chat.toPlainText() != txt:
                      chat.setPlainText(txt)
                  board.update()

              tm = QtCore.QTimer(w)
              tm.timeout.connect(tick)
              tm.start(40)
              w.resize(1280, 720)
              w.show()
              board.setFocus()
              self.win = (w, tm)
    bot: '0'
    comment: 'Among Us Lite v2 node (up to 16 players, 2 maps, vents, sabotage, new roles). node_id 0 = host. map_pref: 0 random, 1/2 fixed.'
    guard_ms: guard_ms
    key: game_key
    map_pref: '0'
    min_players: '3'
    n_players: n_players
    node_id: '0'
    show_gui: '1'
    slot_ms: slot_ms
    tick_ms: tick_ms
    title: '''Among Us Lite'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [analog_agc_xx_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', channel_model_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channel_model_0, '0', blocks_throttle_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_crc_append_0, out, epy_rs_encoder, pdu_in]
- [digital_crc_check_0_0, ok, game_client_1, rx_in]
- [digital_crc_check_0_0, ok, game_client_2, rx_in]
- [digital_crc_check_0_0, ok, game_client_3, rx_in]
- [digital_crc_check_0_0, ok, game_host, rx_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_rs_decoder, pdu_out, digital_crc_check_0_0, in]
- [epy_rs_encoder, pdu_out, digital_protocol_formatter_async_0, in]
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [game_client_1, tx_out, digital_crc_append_0, in]
- [game_client_2, tx_out, digital_crc_append_0, in]
- [game_client_3, tx_out, digital_crc_append_0, in]
- [game_host, tx_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_rs_decoder, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
